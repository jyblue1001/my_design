v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {r=7769} 1980 -1000 0 0 0.4 0.4 {}
N 1180 -1770 1180 -1150 {lab=V_REF_MIR}
N 1740 -1770 1740 -1150 {lab=V_REF}
N 1180 -1900 1180 -1830 {lab=VDDA}
N 1740 -1900 1740 -1830 {lab=VDDA}
N 1180 -1090 1180 -1020 {lab=GNDA}
N 1740 -1090 1740 -1020 {lab=V_RES}
N 1180 -1210 1290 -1210 {lab=V_REF_MIR}
N 1290 -1210 1290 -1120 {lab=V_REF_MIR}
N 1740 -1800 1780 -1800 {lab=VDDA}
N 1780 -1860 1780 -1800 {lab=VDDA}
N 1740 -1860 1780 -1860 {lab=VDDA}
N 1140 -1800 1180 -1800 {lab=VDDA}
N 1140 -1860 1140 -1800 {lab=VDDA}
N 1140 -1860 1180 -1860 {lab=VDDA}
N 1140 -1060 1180 -1060 {lab=GNDA}
N 1140 -1120 1140 -1060 {lab=GNDA}
N 1140 -1120 1180 -1120 {lab=GNDA}
N 1740 -1120 1870 -1120 {lab=GNDA}
N 730 -1460 730 -1290 {lab=START_UP}
N 730 -1590 730 -1520 {lab=#net12}
N 690 -1490 730 -1490 {lab=#net12}
N 690 -1550 690 -1490 {lab=#net12}
N 690 -1550 730 -1550 {lab=#net12}
N 690 -1260 690 -1200 {lab=GNDA}
N 690 -1260 730 -1260 {lab=GNDA}
N 920 -1410 990 -1410 {lab=GNDA}
N 730 -1410 880 -1410 {lab=START_UP}
N 770 -1490 800 -1490 {lab=START_UP}
N 800 -1490 800 -1410 {lab=START_UP}
N 920 -1450 920 -1440 {lab=V_REF}
N 920 -1380 920 -1370 {lab=V_REF_MIR}
N 920 -1370 1180 -1370 {lab=V_REF_MIR}
N 1680 -990 1720 -990 {lab=GNDA}
N 1740 -960 1740 -880 {lab=GND}
N 770 -1260 1180 -1260 {lab=V_REF_MIR}
N 730 -1230 730 -1150 {lab=GNDA}
N 730 -1150 730 -1030 {lab=GNDA}
N 690 -1200 730 -1200 {lab=GNDA}
N 1220 -1120 1290 -1120 {lab=V_REF_MIR}
N 1290 -1120 1460 -1120 {lab=V_REF_MIR}
N 1530 -1120 1700 -1120 {lab=V_REF_MIR}
N 1220 -1800 1630 -1800 {lab=V_REF}
N 1630 -1800 1700 -1800 {lab=V_REF}
N 920 -1450 1630 -1450 {lab=V_REF}
N 2230 -1090 2230 -1020 {lab=GNDA}
N 2230 -1060 2270 -1060 {lab=GNDA}
N 2270 -1120 2270 -1060 {lab=GNDA}
N 2230 -1120 2270 -1120 {lab=GNDA}
N 2230 -1750 2230 -1680 {lab=VDDA}
N 2190 -1650 2230 -1650 {lab=VDDA}
N 2190 -1710 2190 -1650 {lab=VDDA}
N 2190 -1710 2230 -1710 {lab=VDDA}
N 2230 -1620 2230 -1150 {lab=VBIAS2}
N 2660 -1900 3080 -1900 {lab=VBIAS1}
N 2620 -2000 2620 -1930 {lab=VDDA}
N 3120 -2000 3120 -1930 {lab=VDDA}
N 3120 -1900 3160 -1900 {lab=VDDA}
N 3160 -1960 3160 -1900 {lab=VDDA}
N 3120 -1960 3160 -1960 {lab=VDDA}
N 2580 -1900 2620 -1900 {lab=VDDA}
N 2580 -1960 2580 -1900 {lab=VDDA}
N 2580 -1960 2620 -1960 {lab=VDDA}
N 2620 -1560 2800 -1560 {lab=VBIAS1}
N 2660 -1740 3080 -1740 {lab=VBIAS2}
N 3120 -1740 3160 -1740 {lab=VDDA}
N 3160 -1800 3160 -1740 {lab=VDDA}
N 2580 -1740 2620 -1740 {lab=VDDA}
N 2580 -1800 2580 -1740 {lab=VDDA}
N 2620 -1710 2620 -1520 {lab=VBIAS1}
N 3120 -1710 3120 -1520 {lab=VNCAS}
N 2520 -1650 2720 -1650 {lab=VBIAS2}
N 2720 -1740 2720 -1650 {lab=VBIAS2}
N 2620 -1090 2620 -1020 {lab=GNDA}
N 2620 -1060 2660 -1060 {lab=GNDA}
N 2660 -1120 2660 -1060 {lab=GNDA}
N 2620 -1120 2660 -1120 {lab=GNDA}
N 3120 -1310 3120 -1240 {lab=#net13}
N 3080 -1340 3080 -1280 {lab=GNDA}
N 3080 -1340 3120 -1340 {lab=GNDA}
N 3120 -1520 3120 -1370 {lab=VNCAS}
N 3120 -1440 3430 -1440 {lab=VNCAS}
N 3160 -1340 3250 -1340 {lab=VNCAS}
N 3120 -1090 3120 -1020 {lab=#net14}
N 3160 -1120 3160 -1060 {lab=GNDA}
N 3120 -1120 3160 -1120 {lab=GNDA}
N 3120 -1240 3120 -1150 {lab=#net13}
N 3120 -960 3120 -890 {lab=GNDA}
N 3120 -930 3160 -930 {lab=GNDA}
N 3160 -990 3160 -930 {lab=GNDA}
N 3120 -990 3160 -990 {lab=GNDA}
N 2990 -990 3080 -990 {lab=#net13}
N 3080 -1280 3160 -1280 {lab=GNDA}
N 3160 -1280 3160 -1120 {lab=GNDA}
N 3160 -1060 3160 -990 {lab=GNDA}
N 2990 -1200 2990 -990 {lab=#net13}
N 2990 -1200 3120 -1200 {lab=#net13}
N 2580 -1900 2580 -1800 {lab=VDDA}
N 3160 -1900 3160 -1800 {lab=VDDA}
N 4250 -1810 4250 -1740 {lab=VDDA}
N 4250 -1710 4290 -1710 {lab=VDDA}
N 4290 -1770 4290 -1710 {lab=VDDA}
N 4250 -1770 4290 -1770 {lab=VDDA}
N 4250 -1540 4250 -1470 {lab=#net15}
N 4250 -1680 4250 -1540 {lab=#net15}
N 4250 -1410 4250 -1190 {lab=VBIAS4}
N 4210 -1090 4210 -1030 {lab=GNDA}
N 4250 -1190 4250 -1120 {lab=VBIAS4}
N 4210 -1090 4250 -1090 {lab=GNDA}
N 4250 -1060 4250 -990 {lab=VLOW}
N 2800 -1830 3430 -1830 {lab=VBIAS1}
N 4100 -1710 4100 -1640 {lab=VBIAS1}
N 4100 -1710 4210 -1710 {lab=VBIAS1}
N 4210 -890 4210 -830 {lab=GNDA}
N 4250 -990 4250 -920 {lab=VLOW}
N 4210 -890 4250 -890 {lab=GNDA}
N 4250 -860 4250 -790 {lab=GNDA}
N 4210 -830 4250 -830 {lab=GNDA}
N 4290 -890 4370 -890 {lab=VBIAS4}
N 4370 -1250 4370 -890 {lab=VBIAS4}
N 4250 -1250 4370 -1250 {lab=VBIAS4}
N 2720 -1650 3430 -1650 {lab=VBIAS2}
N 4210 -1030 4210 -890 {lab=GNDA}
N 4700 -1810 4700 -1740 {lab=VDDA}
N 4700 -1710 4740 -1710 {lab=VDDA}
N 4740 -1770 4740 -1710 {lab=VDDA}
N 4700 -1770 4740 -1770 {lab=VDDA}
N 4700 -1540 4700 -1470 {lab=Vds2}
N 4700 -1440 4740 -1440 {lab=VDDA}
N 4740 -1500 4740 -1440 {lab=VDDA}
N 4700 -1680 4700 -1540 {lab=Vds2}
N 4740 -1090 4740 -1030 {lab=GNDA}
N 4700 -1190 4700 -1120 {lab=VPCAS}
N 4740 -1710 4740 -1500 {lab=VDDA}
N 4700 -1090 4740 -1090 {lab=GNDA}
N 4700 -1060 4700 -990 {lab=Vds3}
N 4590 -1710 4590 -1640 {lab=Vgs2}
N 4590 -1710 4660 -1710 {lab=Vgs2}
N 4740 -890 4740 -830 {lab=GNDA}
N 4700 -990 4700 -920 {lab=Vds3}
N 4700 -890 4740 -890 {lab=GNDA}
N 4700 -860 4700 -790 {lab=GNDA}
N 4700 -830 4740 -830 {lab=GNDA}
N 4580 -890 4660 -890 {lab=VBIAS4}
N 4490 -1440 4660 -1440 {lab=VBIAS2}
N 4740 -1030 4740 -890 {lab=GNDA}
N 4370 -890 4580 -890 {lab=VBIAS4}
N 4290 -1090 4660 -1090 {lab=VBIAS3}
N 4490 -1180 4490 -1090 {lab=VBIAS3}
N 4700 -1310 4740 -1310 {lab=VDDA}
N 4740 -1370 4740 -1310 {lab=VDDA}
N 4590 -1310 4590 -1220 {lab=VPCAS}
N 4590 -1310 4660 -1310 {lab=VPCAS}
N 4740 -1440 4740 -1370 {lab=VDDA}
N 4700 -1410 4700 -1340 {lab=Vgs2}
N 4590 -1640 4590 -1380 {lab=Vgs2}
N 4590 -1380 4700 -1380 {lab=Vgs2}
N 4700 -1280 4700 -1190 {lab=VPCAS}
N 4590 -1220 4700 -1220 {lab=VPCAS}
N 4700 -1220 4960 -1220 {lab=VPCAS}
N 2910 -1120 3080 -1120 {lab=VBIAS3}
N 4490 -1180 4960 -1180 {lab=VBIAS3}
N 4250 -1020 4960 -1020 {lab=VLOW}
N 4370 -970 4960 -970 {lab=VBIAS4}
N 1590 -1800 1590 -1710 {lab=V_REF}
N 2270 -1650 2350 -1650 {lab=VBIAS2}
N 1590 -1710 1590 -1660 {lab=V_REF}
N 4050 -1640 4100 -1640 {lab=VBIAS1}
N 1460 -1120 1530 -1120 {lab=V_REF_MIR}
N 1590 -1660 1740 -1660 {lab=V_REF}
N 1630 -1450 1740 -1450 {lab=V_REF}
N 2120 -1120 2190 -1120 {lab=V_REF_MIR}
N 2350 -1650 2350 -1540 {lab=VBIAS2}
N 2230 -1540 2350 -1540 {lab=VBIAS2}
N 1290 -1210 2120 -1210 {lab=V_REF_MIR}
N 2120 -1210 2120 -1120 {lab=V_REF_MIR}
N 2620 -1520 2620 -1150 {lab=VBIAS1}
N 2620 -1870 2620 -1770 {lab=VHIGH}
N 3120 -1870 3120 -1770 {lab=#net16}
N 2350 -1650 2520 -1650 {lab=VBIAS2}
N 2120 -1210 2480 -1210 {lab=V_REF_MIR}
N 2480 -1210 2480 -1120 {lab=V_REF_MIR}
N 2480 -1120 2580 -1120 {lab=V_REF_MIR}
N 3250 -1440 3250 -1340 {lab=VNCAS}
N 4250 -1440 4290 -1440 {lab=VDDA}
N 4290 -1500 4290 -1440 {lab=VDDA}
N 4290 -1710 4290 -1500 {lab=VDDA}
N 3910 -1810 3910 -1740 {lab=VDDA}
N 3910 -1710 3950 -1710 {lab=VDDA}
N 3950 -1770 3950 -1710 {lab=VDDA}
N 3910 -1770 3950 -1770 {lab=VDDA}
N 3760 -1710 3760 -1640 {lab=VBIAS1}
N 3760 -1710 3870 -1710 {lab=VBIAS1}
N 3870 -1180 3870 -1120 {lab=GNDA}
N 3870 -1180 3910 -1180 {lab=GNDA}
N 3910 -1150 3910 -1080 {lab=GNDA}
N 3870 -1120 3910 -1120 {lab=GNDA}
N 3950 -1180 4030 -1180 {lab=VBIAS3}
N 4030 -1300 4030 -1180 {lab=VBIAS3}
N 3910 -1300 4030 -1300 {lab=VBIAS3}
N 3910 -1440 3950 -1440 {lab=VDDA}
N 3950 -1500 3950 -1440 {lab=VDDA}
N 3950 -1710 3950 -1500 {lab=VDDA}
N 3910 -1410 3910 -1210 {lab=VBIAS3}
N 3760 -1640 4050 -1640 {lab=VBIAS1}
N 3660 -1440 3870 -1440 {lab=VBIAS2}
N 3660 -1640 3760 -1640 {lab=VBIAS1}
N 4030 -1180 4490 -1180 {lab=VBIAS3}
N 2620 -1790 3430 -1790 {lab=VHIGH}
N 2800 -1900 2800 -1560 {lab=VBIAS1}
N 4100 -1440 4210 -1440 {lab=VBIAS2}
N 4100 -1540 4100 -1440 {lab=VBIAS2}
N 3760 -1540 4100 -1540 {lab=VBIAS2}
N 3760 -1540 3760 -1440 {lab=VBIAS2}
N 3910 -1680 3910 -1470 {lab=#net17}
C {lab_pin.sym} 3430 -1790 0 1 {name=p5 sig_type=std_logic lab=VHIGH}
C {lab_wire.sym} 3430 -1440 0 1 {name=p7 sig_type=std_logic lab=VNCAS}
C {iopin.sym} 4700 -1810 0 0 {name=p45 lab=VDDA}
C {opin.sym} 3430 -1830 0 0 {name=p32 lab=VBIAS1}
C {opin.sym} 3430 -1650 0 0 {name=p4 lab=VBIAS2}
C {opin.sym} 4960 -1180 0 0 {name=p6 lab=VBIAS3}
C {opin.sym} 4960 -970 0 0 {name=p46 lab=VBIAS4}
C {sky130_fd_pr/nfet_01v8.sym} 1720 -1120 0 0 {name=M34
W=16
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1200 -1120 0 1 {name=M35
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 -1260 0 1 {name=M36
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 900 -1410 0 0 {name=M37
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1740 -880 0 0 {name=l1 lab=GND}
C {lab_pin.sym} 1740 -1050 0 1 {name=p47 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 730 -1410 0 0 {name=p48 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 750 -1490 0 1 {name=M38
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1720 -1800 0 0 {name=M39
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1200 -1800 0 1 {name=M40
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 1900 -1040 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 1740 -1390 0 1 {name=p49 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2210 -1120 0 0 {name=M41
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2250 -1650 0 1 {name=M42
W=12
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3100 -1900 0 0 {name=M43
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2640 -1900 0 1 {name=M44
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3100 -1740 0 0 {name=M45
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2640 -1740 0 1 {name=M46
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2600 -1120 0 0 {name=M47
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3140 -1340 0 1 {name=M48
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3100 -1120 0 0 {name=M49
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3100 -990 0 0 {name=M50
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4230 -1710 0 0 {name=M51
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4270 -1090 0 1 {name=M52
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4270 -890 0 1 {name=M53
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4680 -1710 0 0 {name=M54
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4680 -1440 0 0 {name=M55
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4680 -1090 0 0 {name=M56
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4680 -890 0 0 {name=M57
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4680 -1310 0 0 {name=M58
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4960 -1220 0 1 {name=p54 sig_type=std_logic lab=VPCAS}
C {lab_wire.sym} 2910 -1120 2 1 {name=p55 sig_type=std_logic lab=VBIAS3}
C {lab_wire.sym} 4960 -1020 0 1 {name=p56 sig_type=std_logic lab=VLOW}
C {lab_wire.sym} 4700 -1590 0 0 {name=p59 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 4590 -1590 0 0 {name=p60 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 4700 -990 0 0 {name=p61 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 1290 -1210 2 0 {name=p62 sig_type=std_logic lab=V_REF_MIR}
C {lab_wire.sym} 4490 -1440 0 0 {name=p63 sig_type=std_logic lab=VBIAS2}
C {sky130_fd_pr/res_high_po_0p35.sym} 1740 -990 0 0 {name=R2
L=13
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 4230 -1440 0 0 {name=M59
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3890 -1710 0 0 {name=M60
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3930 -1180 0 1 {name=M61
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3890 -1440 0 0 {name=M62
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 3660 -1640 0 0 {name=p64 sig_type=std_logic lab=VBIAS1}
C {lab_wire.sym} 3660 -1440 0 0 {name=p65 sig_type=std_logic lab=VBIAS2}
C {iopin.sym} 4700 -790 0 0 {name=p66 lab=GNDA}
C {lab_wire.sym} 4250 -790 2 0 {name=p43 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 4250 -1810 0 1 {name=p50 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 3910 -1080 2 0 {name=p51 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 3910 -1810 0 1 {name=p52 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 3120 -2000 0 1 {name=p53 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 2620 -2000 0 1 {name=p57 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 3120 -890 2 0 {name=p58 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 2620 -1020 2 0 {name=p67 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 2230 -1020 2 0 {name=p68 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 2230 -1750 0 1 {name=p69 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 1740 -1900 0 1 {name=p70 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 1180 -1900 0 1 {name=p71 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 1180 -1020 2 0 {name=p72 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 730 -1030 2 0 {name=p73 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 1870 -1120 2 0 {name=p74 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 1680 -990 2 1 {name=p75 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 990 -1410 2 0 {name=p76 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 730 -1590 0 1 {name=p77 sig_type=std_logic lab=VDDA}
