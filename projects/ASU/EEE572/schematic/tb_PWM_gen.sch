v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 980 -2540 1210 -2380 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.2e-13









color=7
node=v_ref}
B 2 6430 -1350 7090 -900 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.061











color="7 18"
node="clk_swcap


q"}
B 2 5620 -1350 6280 -900 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00013












color=6
node=s_rst}
B 2 6430 -830 7090 -380 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=6
























y1=1.5












color=7
node=v_ctrl_vtc}
B 2 4460 -2130 4720 -1940 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00012












color=6
node=s_rst}
B 2 4460 -1920 4720 -1730 {flags=graph

y2=0.0008
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.00075












color="6 7"
node="i(@m.xm37.msky130_fd_pr__nfet_01v8[id])
i(vmeas)"}
B 2 6030 -1820 6290 -1630 {flags=graph

y2=1.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color=6
node=i(@m.xm34.msky130_fd_pr__nfet_01v8[id])}
B 2 5670 -1820 5930 -1630 {flags=graph

y2=3e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=3e-09












color="6 7"
node="i(@m.xm38.msky130_fd_pr__nfet_01v8[id])
i(@m.xm39.msky130_fd_pr__nfet_01v8[id])"}
B 2 6330 -1820 6590 -1630 {flags=graph

y2=0.00017
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color="6 7 11"
node="i(@m.xm34.msky130_fd_pr__nfet_01v8[id])
i(@m.xm36.msky130_fd_pr__pfet_01v8[id])
i(@m.xm35.msky130_fd_pr__nfet_01v8[id])"}
B 2 6030 -1610 6290 -1420 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.79













color=7
node=pull_down}
B 2 5360 -1820 5620 -1630 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.012













color="7 6"
node="vin_p
v_ctrl_vtc"}
B 2 5670 -1610 5930 -1420 {flags=graph

y2=0.57
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00034














color=7
node=amp_out}
B 2 6830 -2900 7090 -2710 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0













color="7 6"
node="v_sawtooth
v_err_amp_out"}
B 2 7570 -2900 7830 -2710 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.052














color=6
node=v_q_b}
B 2 6830 -3110 7090 -2920 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.09














color=6
node=v_err_amp_out}
B 2 7570 -2680 7830 -2490 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.018














color=7
node=v_final_pwm}
B 2 7120 -2900 7380 -2710 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0018















color=7
node=clk_out}
T {3.1uA} 5690 -2550 0 0 1 1 {}
T {100nA} 6160 -2540 0 0 1 1 {}
T {24/(0.3 * 2)} 5700 -2670 0 0 0.5 0.5 {}
T {24/(0.3 * 8)} 6240 -2680 0 0 0.5 0.5 {}
N 660 -2930 660 -2310 {lab=V_REF_MIR}
N 1610 -2930 1610 -2310 {lab=V_REF}
N 660 -3060 660 -2990 {lab=VDD}
N 1610 -3060 1610 -2990 {lab=VDD}
N 660 -2250 660 -2180 {lab=GND}
N 1610 -2250 1610 -2180 {lab=V_RES}
N 660 -2370 770 -2370 {lab=V_REF_MIR}
N 770 -2370 770 -2280 {lab=V_REF_MIR}
N 1610 -2960 1650 -2960 {lab=VDD}
N 1650 -3020 1650 -2960 {lab=VDD}
N 1610 -3020 1650 -3020 {lab=VDD}
N 620 -2960 660 -2960 {lab=VDD}
N 620 -3020 620 -2960 {lab=VDD}
N 620 -3020 660 -3020 {lab=VDD}
N 620 -2220 660 -2220 {lab=GND}
N 620 -2280 620 -2220 {lab=GND}
N 620 -2280 660 -2280 {lab=GND}
N 1610 -2280 1740 -2280 {lab=GND}
N 210 -2620 210 -2450 {lab=START_UP}
N 210 -2750 210 -2680 {lab=VDD}
N 170 -2650 210 -2650 {lab=VDD}
N 170 -2710 170 -2650 {lab=VDD}
N 170 -2710 210 -2710 {lab=VDD}
N 170 -2420 170 -2360 {lab=GND}
N 170 -2420 210 -2420 {lab=GND}
N 400 -2570 470 -2570 {lab=GND}
N 210 -2570 360 -2570 {lab=START_UP}
N 250 -2650 280 -2650 {lab=START_UP}
N 280 -2650 280 -2570 {lab=START_UP}
N 400 -2610 400 -2600 {lab=Vbiasp}
N 400 -2540 400 -2530 {lab=V_REF_MIR}
N 400 -2530 660 -2530 {lab=V_REF_MIR}
N 1550 -2150 1590 -2150 {lab=GND}
N 1610 -2120 1610 -2040 {lab=GND}
N 250 -2420 660 -2420 {lab=V_REF_MIR}
N 210 -2390 210 -2310 {lab=GND}
N 210 -2310 210 -2190 {lab=GND}
N 170 -2360 210 -2360 {lab=GND}
N 910 -3110 910 -2130 {lab=Vbiasp_MIR}
N 1290 -3110 1290 -2130 {lab=Vbiasp}
N 950 -3140 1250 -3140 {lab=Vbiasp_MIR}
N 910 -3240 910 -3170 {lab=VDD}
N 1290 -3240 1290 -3170 {lab=VDD}
N 910 -2070 910 -2000 {lab=GND}
N 1290 -2070 1290 -2000 {lab=GND}
N 1290 -3140 1330 -3140 {lab=VDD}
N 1330 -3200 1330 -3140 {lab=VDD}
N 1290 -3200 1330 -3200 {lab=VDD}
N 870 -3140 910 -3140 {lab=VDD}
N 870 -3200 870 -3140 {lab=VDD}
N 870 -3200 910 -3200 {lab=VDD}
N 870 -2040 910 -2040 {lab=GND}
N 870 -2100 870 -2040 {lab=GND}
N 870 -2100 910 -2100 {lab=GND}
N 1290 -2040 1330 -2040 {lab=GND}
N 1330 -2100 1330 -2040 {lab=GND}
N 1290 -2100 1330 -2100 {lab=GND}
N 1090 -3140 1090 -3030 {lab=Vbiasp_MIR}
N 910 -3030 1090 -3030 {lab=Vbiasp_MIR}
N 700 -2280 770 -2280 {lab=V_REF_MIR}
N 770 -2280 1120 -2280 {lab=V_REF_MIR}
N 1120 -2280 1250 -2100 {lab=V_REF_MIR}
N 950 -2100 1190 -2280 {lab=V_REF}
N 1190 -2280 1570 -2280 {lab=V_REF}
N 1490 -2370 1490 -2280 {lab=V_REF}
N 1490 -2370 1610 -2370 {lab=V_REF}
N 700 -2960 1290 -2960 {lab=Vbiasp}
N 1290 -2960 1570 -2960 {lab=Vbiasp}
N 400 -2610 1290 -2610 {lab=Vbiasp}
N 2010 -2120 2010 -2050 {lab=GND}
N 1970 -2090 2010 -2090 {lab=GND}
N 1970 -2150 1970 -2090 {lab=GND}
N 1970 -2150 2010 -2150 {lab=GND}
N 2010 -2780 2010 -2710 {lab=VDD}
N 2010 -2680 2050 -2680 {lab=VDD}
N 2050 -2740 2050 -2680 {lab=VDD}
N 2010 -2740 2050 -2740 {lab=VDD}
N 2010 -2650 2010 -2180 {lab=Vbias3}
N 3780 -2780 4080 -2780 {lab=Vbias1}
N 3740 -2880 3740 -2810 {lab=VDD}
N 4120 -2880 4120 -2810 {lab=VDD}
N 4120 -2780 4160 -2780 {lab=VDD}
N 4160 -2840 4160 -2780 {lab=VDD}
N 4120 -2840 4160 -2840 {lab=VDD}
N 3700 -2780 3740 -2780 {lab=VDD}
N 3700 -2840 3700 -2780 {lab=VDD}
N 3700 -2840 3740 -2840 {lab=VDD}
N 3920 -2780 3920 -2670 {lab=Vbias1}
N 3740 -2330 3920 -2330 {lab=Vbias1}
N 3780 -2510 4080 -2510 {lab=Vbias2}
N 3740 -2610 3740 -2540 {lab=Vhigh}
N 4120 -2610 4120 -2540 {lab=#net1}
N 4120 -2510 4160 -2510 {lab=VDD}
N 4160 -2570 4160 -2510 {lab=VDD}
N 3700 -2510 3740 -2510 {lab=VDD}
N 3700 -2570 3700 -2510 {lab=VDD}
N 3740 -2750 3740 -2610 {lab=Vhigh}
N 4120 -2750 4120 -2610 {lab=#net1}
N 3920 -2670 3920 -2330 {lab=Vbias1}
N 3740 -2480 3740 -2260 {lab=Vbias1}
N 4120 -2480 4120 -2260 {lab=Vncas}
N 3640 -2420 3840 -2420 {lab=Vbias2}
N 3840 -2510 3840 -2420 {lab=Vbias2}
N 3740 -1830 3740 -1760 {lab=GND}
N 3740 -1800 3780 -1800 {lab=GND}
N 3780 -1860 3780 -1800 {lab=GND}
N 3740 -1860 3780 -1860 {lab=GND}
N 3740 -1950 3740 -1890 {lab=#net2}
N 3550 -1860 3700 -1860 {lab=Vbias4}
N 4120 -2050 4120 -1980 {lab=Vncas_btw}
N 4080 -2080 4080 -2020 {lab=GND}
N 4080 -2080 4120 -2080 {lab=GND}
N 4120 -2260 4120 -2110 {lab=Vncas}
N 4120 -2300 4430 -2300 {lab=Vncas}
N 4160 -2080 4250 -2080 {lab=Vncas}
N 4120 -1830 4120 -1760 {lab=#net3}
N 4160 -1860 4160 -1800 {lab=GND}
N 4120 -1860 4160 -1860 {lab=GND}
N 4120 -1980 4120 -1890 {lab=Vncas_btw}
N 4120 -1700 4120 -1630 {lab=GND}
N 4120 -1670 4160 -1670 {lab=GND}
N 4160 -1730 4160 -1670 {lab=GND}
N 4120 -1730 4160 -1730 {lab=GND}
N 3990 -1730 4080 -1730 {lab=Vncas_btw}
N 4080 -2020 4160 -2020 {lab=GND}
N 4160 -2020 4160 -1860 {lab=GND}
N 4160 -1800 4160 -1730 {lab=GND}
N 3990 -1940 3990 -1730 {lab=Vncas_btw}
N 3990 -1940 4120 -1940 {lab=Vncas_btw}
N 3700 -2780 3700 -2570 {lab=VDD}
N 4160 -2780 4160 -2570 {lab=VDD}
N 2350 -2780 2350 -2710 {lab=VDD}
N 2350 -2680 2390 -2680 {lab=VDD}
N 2390 -2740 2390 -2680 {lab=VDD}
N 2350 -2740 2390 -2740 {lab=VDD}
N 2350 -2510 2350 -2440 {lab=Vbias4}
N 2350 -2650 2350 -2510 {lab=Vbias4}
N 2350 -2380 2350 -2160 {lab=Vbias4}
N 2310 -2060 2310 -2000 {lab=GND}
N 2350 -2160 2350 -2090 {lab=Vbias4}
N 2310 -2060 2350 -2060 {lab=GND}
N 2350 -2030 2350 -1960 {lab=Vlow}
N 3920 -2710 4430 -2710 {lab=Vbias1}
N 2200 -2680 2200 -2610 {lab=Vbiasp}
N 2200 -2680 2310 -2680 {lab=Vbiasp}
N 2310 -1860 2310 -1800 {lab=GND}
N 2350 -1960 2350 -1890 {lab=Vlow}
N 2310 -1860 2350 -1860 {lab=GND}
N 2350 -1830 2350 -1760 {lab=GND}
N 2310 -1800 2350 -1800 {lab=GND}
N 2390 -1860 2470 -1860 {lab=Vbias4}
N 2470 -2220 2470 -1860 {lab=Vbias4}
N 2350 -2220 2470 -2220 {lab=Vbias4}
N 3840 -2420 4430 -2420 {lab=Vbias2}
N 4250 -2300 4250 -2080 {lab=Vncas}
N 2310 -2000 2310 -1860 {lab=GND}
N 2800 -2780 2800 -2710 {lab=VDD}
N 2800 -2680 2840 -2680 {lab=VDD}
N 2840 -2740 2840 -2680 {lab=VDD}
N 2800 -2740 2840 -2740 {lab=VDD}
N 2800 -2510 2800 -2440 {lab=Vds2}
N 2800 -2410 2840 -2410 {lab=VDD}
N 2840 -2470 2840 -2410 {lab=VDD}
N 2800 -2650 2800 -2510 {lab=Vds2}
N 2840 -2060 2840 -2000 {lab=GND}
N 2800 -2160 2800 -2090 {lab=Vpcas}
N 2840 -2680 2840 -2470 {lab=VDD}
N 2800 -2060 2840 -2060 {lab=GND}
N 2800 -2030 2800 -1960 {lab=Vds3}
N 2690 -2680 2690 -2610 {lab=Vgs2}
N 2690 -2680 2760 -2680 {lab=Vgs2}
N 2840 -1860 2840 -1800 {lab=GND}
N 2800 -1960 2800 -1890 {lab=Vds3}
N 2800 -1860 2840 -1860 {lab=GND}
N 2800 -1830 2800 -1760 {lab=GND}
N 2800 -1800 2840 -1800 {lab=GND}
N 2680 -1860 2760 -1860 {lab=Vbias4}
N 2590 -2410 2760 -2410 {lab=Vbias2}
N 2840 -2000 2840 -1860 {lab=GND}
N 2470 -1860 2680 -1860 {lab=Vbias4}
N 2390 -2060 2760 -2060 {lab=Vbias3}
N 2590 -2150 2590 -2060 {lab=Vbias3}
N 2800 -2280 2840 -2280 {lab=VDD}
N 2840 -2340 2840 -2280 {lab=VDD}
N 2690 -2280 2690 -2190 {lab=Vpcas}
N 2690 -2280 2760 -2280 {lab=Vpcas}
N 2840 -2410 2840 -2340 {lab=VDD}
N 2800 -2380 2800 -2310 {lab=Vgs2}
N 2690 -2610 2690 -2350 {lab=Vgs2}
N 2690 -2350 2800 -2350 {lab=Vgs2}
N 2800 -2250 2800 -2160 {lab=Vpcas}
N 2690 -2190 2800 -2190 {lab=Vpcas}
N 2800 -2190 3060 -2190 {lab=Vpcas}
N 3890 -1860 4080 -1860 {lab=Vbias3}
N 1870 -2610 1900 -2610 {lab=Vbiasp}
N 2590 -2150 3060 -2150 {lab=Vbias3}
N 2350 -1990 3060 -1990 {lab=Vlow}
N 2470 -1940 3060 -1940 {lab=Vbias4}
N 3740 -2630 4430 -2630 {lab=Vhigh}
N 1460 -2960 1460 -2870 {lab=Vbiasp}
N 1890 -2680 1970 -2680 {lab=Vbiasp}
N 1460 -2680 1890 -2680 {lab=Vbiasp}
N 1460 -2870 1460 -2680 {lab=Vbiasp}
N 2350 -2440 2350 -2380 {lab=Vbias4}
N 2050 -2150 2260 -2150 {lab=Vbias3}
N 2120 -2260 2120 -2150 {lab=Vbias3}
N 2010 -2260 2120 -2260 {lab=Vbias3}
N 1900 -2610 2200 -2610 {lab=Vbiasp}
N 1870 -2680 1870 -2610 {lab=Vbiasp}
N 2260 -2150 2590 -2150 {lab=Vbias3}
N 3740 -2040 3740 -1950 {lab=#net2}
N 3740 -2070 3780 -2070 {lab=GND}
N 3740 -2260 3740 -2100 {lab=Vbias1}
N 3780 -2070 3780 -1860 {lab=GND}
N 3550 -2070 3700 -2070 {lab=Vbias3}
N 3350 -2420 3390 -2420 {lab=VDD}
N 3390 -2390 3390 -2260 {lab=Vbias2}
N 3390 -1830 3390 -1760 {lab=GND}
N 3390 -1800 3430 -1800 {lab=GND}
N 3430 -1860 3430 -1800 {lab=GND}
N 3390 -1860 3430 -1860 {lab=GND}
N 3390 -1950 3390 -1890 {lab=#net4}
N 3200 -1860 3350 -1860 {lab=Vbias4}
N 3390 -2040 3390 -1950 {lab=#net4}
N 3390 -2070 3430 -2070 {lab=GND}
N 3390 -2260 3390 -2100 {lab=Vbias2}
N 3430 -2070 3430 -1860 {lab=GND}
N 3200 -2070 3350 -2070 {lab=Vbias3}
N 3390 -2520 3390 -2450 {lab=VDD}
N 3350 -2480 3350 -2420 {lab=VDD}
N 3350 -2480 3390 -2480 {lab=VDD}
N 3430 -2420 3640 -2420 {lab=Vbias2}
N 3480 -2420 3480 -2330 {lab=Vbias2}
N 3390 -2330 3480 -2330 {lab=Vbias2}
N 3060 -2150 3200 -2150 {lab=Vbias3}
N 3200 -2150 3200 -2070 {lab=Vbias3}
N 3060 -1940 3200 -1940 {lab=Vbias4}
N 3200 -1940 3200 -1860 {lab=Vbias4}
N 3550 -2150 3550 -2070 {lab=Vbias3}
N 3550 -1940 3550 -1860 {lab=Vbias4}
N 3200 -1940 3550 -1940 {lab=Vbias4}
N 3200 -2150 3550 -2150 {lab=Vbias3}
N 3550 -2150 3890 -2150 {lab=Vbias3}
N 3890 -2150 3890 -1860 {lab=Vbias3}
N 1780 -2910 1780 -2820 {lab=VDD}
N 1780 -2760 1780 -2680 {lab=Vbiasp}
N 5490 -2000 5790 -2000 {lab=AMP_MIR}
N 5450 -2480 5450 -2410 {lab=Vp}
N 5830 -2480 5830 -2410 {lab=Vp}
N 5450 -2350 5450 -2270 {lab=VD1}
N 5830 -2350 5830 -2270 {lab=VD2}
N 5830 -2210 5830 -2030 {lab=AMP_OUT}
N 5450 -2210 5450 -2030 {lab=AMP_MIR}
N 5450 -1900 5830 -1900 {lab=GND}
N 5630 -1900 5630 -1870 {lab=GND}
N 5350 -2380 5410 -2380 {lab=V_ERR_AMP_OUT}
N 5870 -2380 5940 -2380 {lab=V_SAWTOOTH}
N 6820 -2380 6820 -2330 {lab=V_CTRL_VTC}
N 5450 -2080 5630 -2080 {lab=AMP_MIR}
N 5630 -2080 5630 -2000 {lab=AMP_MIR}
N 5380 -2000 5380 -1900 {lab=GND}
N 5380 -1900 5450 -1900 {lab=GND}
N 5380 -2000 5450 -2000 {lab=GND}
N 5900 -2000 5900 -1900 {lab=GND}
N 5830 -1900 5900 -1900 {lab=GND}
N 5830 -2000 5900 -2000 {lab=GND}
N 5380 -2240 5380 -2000 {lab=GND}
N 5900 -2240 5900 -2000 {lab=GND}
N 5450 -2240 5830 -2240 {lab=VDD}
N 5450 -2380 5830 -2380 {lab=VDD}
N 5680 -2380 5680 -2240 {lab=VDD}
N 5450 -1970 5450 -1900 {lab=GND}
N 5830 -1970 5830 -1900 {lab=GND}
N 6160 -2000 6160 -1900 {lab=GND}
N 6120 -1900 6160 -1900 {lab=GND}
N 6120 -2000 6160 -2000 {lab=GND}
N 6120 -1970 6120 -1900 {lab=GND}
N 6460 -2000 6460 -1900 {lab=GND}
N 6420 -1900 6460 -1900 {lab=GND}
N 6420 -2000 6460 -2000 {lab=GND}
N 6420 -1970 6420 -1900 {lab=GND}
N 5950 -2080 5950 -2000 {lab=AMP_OUT}
N 5950 -2000 6080 -2000 {lab=AMP_OUT}
N 6120 -2560 6120 -2030 {lab=PULL_DOWN}
N 6330 -2080 6330 -2000 {lab=PULL_DOWN}
N 6330 -2000 6380 -2000 {lab=PULL_DOWN}
N 6420 -2210 6420 -2030 {lab=CLK_OUT}
N 6330 -2240 6330 -2080 {lab=PULL_DOWN}
N 6330 -2240 6380 -2240 {lab=PULL_DOWN}
N 6120 -2130 6330 -2130 {lab=PULL_DOWN}
N 6460 -2310 6460 -2240 {lab=VDD}
N 6420 -2240 6460 -2240 {lab=VDD}
N 6420 -2310 6420 -2270 {lab=VDD}
N 6420 -2310 6460 -2310 {lab=VDD}
N 6420 -2360 6420 -2310 {lab=VDD}
N 5450 -2480 5830 -2480 {lab=Vp}
N 5640 -2560 5640 -2480 {lab=Vp}
N 6420 -2130 6560 -2130 {lab=CLK_OUT}
N 5380 -2240 5410 -2240 {lab=GND}
N 5870 -2240 5900 -2240 {lab=GND}
N 5900 -1900 6120 -1900 {lab=GND}
N 6160 -1900 6420 -1900 {lab=GND}
N 5640 -2590 5680 -2590 {lab=VDD}
N 5560 -2590 5600 -2590 {lab=Vbias1}
N 5460 -2590 5560 -2590 {lab=Vbias1}
N 5200 -2380 5350 -2380 {lab=V_ERR_AMP_OUT}
N 5680 -2590 5680 -2380 {lab=VDD}
N 5640 -2670 5680 -2670 {lab=VDD}
N 5640 -2710 5640 -2620 {lab=VDD}
N 5680 -2670 5680 -2590 {lab=VDD}
N 6120 -2590 6160 -2590 {lab=VDD}
N 6040 -2590 6080 -2590 {lab=Vbias1}
N 5990 -2590 6040 -2590 {lab=Vbias1}
N 6120 -2670 6160 -2670 {lab=VDD}
N 6160 -2670 6160 -2590 {lab=VDD}
N 6120 -2710 6120 -2620 {lab=VDD}
N 5830 -2080 5950 -2080 {lab=AMP_OUT}
N 7510 -520 7510 -500 {lab=VDD}
N 7510 -440 7510 -420 {lab=GND}
N 6160 -3620 6160 -3580 {
lab=VDD}
N 6160 -3550 6200 -3550 {
lab=VDD}
N 6200 -3600 6200 -3550 {
lab=VDD}
N 6160 -3600 6200 -3600 {
lab=VDD}
N 6160 -3040 6200 -3040 {
lab=GND}
N 6160 -3060 6160 -3010 {
lab=GND}
N 6160 -3090 6200 -3090 {
lab=GND}
N 5770 -3620 5770 -3580 {
lab=VDD}
N 5770 -3550 5810 -3550 {
lab=VDD}
N 5810 -3600 5810 -3550 {
lab=VDD}
N 5770 -3600 5810 -3600 {
lab=VDD}
N 5770 -3310 5810 -3310 {
lab=GND}
N 5810 -3310 5810 -3040 {
lab=GND}
N 5770 -3040 5810 -3040 {
lab=GND}
N 5770 -3060 5770 -3010 {
lab=GND}
N 5770 -3090 5810 -3090 {
lab=GND}
N 5300 -3620 5300 -3580 {
lab=VDD}
N 5300 -3550 5340 -3550 {
lab=VDD}
N 5340 -3600 5340 -3550 {
lab=VDD}
N 5300 -3600 5340 -3600 {
lab=VDD}
N 5300 -3310 5340 -3310 {
lab=VDD}
N 5300 -3040 5340 -3040 {
lab=GND}
N 5300 -3060 5300 -3010 {
lab=GND}
N 5300 -3090 5340 -3090 {
lab=GND}
N 5340 -3550 5340 -3310 {
lab=VDD}
N 6020 -3550 6120 -3550 {
lab=#net5}
N 6020 -3090 6120 -3090 {
lab=#net6}
N 5770 -3490 6020 -3490 {
lab=#net5}
N 5150 -3550 5260 -3550 {
lab=V_Q_B}
N 5150 -3550 5150 -3180 {
lab=V_Q_B}
N 5220 -3310 5260 -3310 {
lab=CK1}
N 5340 -3090 5340 -3040 {
lab=GND}
N 6020 -3150 6020 -3090 {
lab=#net6}
N 5770 -3150 6020 -3150 {
lab=#net6}
N 5560 -3090 5730 -3090 {
lab=#net7}
N 5560 -3150 5560 -3090 {
lab=#net7}
N 5300 -3150 5560 -3150 {
lab=#net7}
N 5560 -3550 5730 -3550 {
lab=#net8}
N 5560 -3550 5560 -3490 {
lab=#net8}
N 5300 -3490 5560 -3490 {
lab=#net8}
N 6020 -3550 6020 -3490 {
lab=#net5}
N 6200 -3090 6200 -3040 {
lab=GND}
N 5960 -3380 5960 -3340 {
lab=#net5}
N 5770 -3380 5960 -3380 {
lab=#net5}
N 5960 -3280 5960 -3260 {
lab=#net6}
N 5770 -3260 5960 -3260 {
lab=#net6}
N 5930 -3310 5960 -3310 {
lab=VDD}
N 5930 -3550 5930 -3310 {
lab=VDD}
N 5810 -3550 5930 -3550 {
lab=VDD}
N 5480 -3380 5480 -3340 {
lab=#net8}
N 5300 -3380 5480 -3380 {
lab=#net8}
N 5480 -3280 5480 -3260 {
lab=#net7}
N 5450 -3310 5480 -3310 {
lab=GND}
N 5300 -3260 5480 -3260 {
lab=#net7}
N 5450 -3310 5450 -3090 {
lab=GND}
N 5340 -3090 5450 -3090 {
lab=GND}
N 5300 -3620 6160 -3620 {
lab=VDD}
N 5770 -3650 5770 -3620 {
lab=VDD}
N 5300 -3010 6160 -3010 {
lab=GND}
N 5770 -3010 5770 -2980 {
lab=GND}
N 5520 -3310 5560 -3310 {
lab=CK1_b}
N 6000 -3310 6040 -3310 {
lab=CK1_b}
N 5690 -3310 5730 -3310 {
lab=CK1}
N 5020 -3400 5150 -3400 {
lab=V_Q_B}
N 5150 -3090 5260 -3090 {
lab=V_Q_B}
N 5150 -3180 5150 -3090 {
lab=V_Q_B}
N 6160 -3390 6300 -3390 {
lab=V_Q_B}
N 6300 -3390 6300 -2920 {
lab=V_Q_B}
N 5020 -2920 6300 -2920 {
lab=V_Q_B}
N 5020 -3400 5020 -2920 {
lab=V_Q_B}
N 5300 -3520 5300 -3340 {
lab=#net8}
N 5300 -3280 5300 -3120 {
lab=#net7}
N 5770 -3520 5770 -3340 {
lab=#net5}
N 5770 -3280 5770 -3120 {
lab=#net6}
N 6160 -3520 6160 -3120 {
lab=V_Q_B}
N 5820 -4410 5820 -4190 {
lab=#net9}
N 5880 -4410 5880 -4190 {
lab=CK1_b}
N 5850 -3920 5850 -3900 {
lab=CK1}
N 5780 -3950 5810 -3950 {
lab=#net10}
N 5780 -3950 5780 -3870 {
lab=#net10}
N 5780 -3870 5810 -3870 {
lab=#net10}
N 5850 -3840 5850 -3820 {
lab=GND}
N 5850 -3870 5870 -3870 {
lab=GND}
N 5870 -3870 5870 -3830 {
lab=GND}
N 5850 -3830 5870 -3830 {
lab=GND}
N 5850 -4000 5850 -3980 {
lab=VDD}
N 5850 -3990 5870 -3990 {
lab=VDD}
N 5870 -3990 5870 -3950 {
lab=VDD}
N 5850 -3950 5870 -3950 {
lab=VDD}
N 5850 -3910 5960 -3910 {
lab=CK1}
N 5330 -4120 5410 -4120 {
lab=CLK_OUT}
N 5880 -4300 5960 -4300 {
lab=CK1_b}
N 5850 -4490 5850 -4450 {
lab=VDD}
N 5850 -4150 5850 -4100 {
lab=GND}
N 5850 -4410 5850 -4380 {
lab=GND}
N 5850 -4380 5910 -4380 {
lab=GND}
N 5910 -4380 5910 -4130 {
lab=GND}
N 5850 -4130 5910 -4130 {
lab=GND}
N 5850 -4210 5850 -4190 {
lab=VDD}
N 5790 -4210 5850 -4210 {
lab=VDD}
N 5790 -4460 5790 -4210 {
lab=VDD}
N 5790 -4460 5850 -4460 {
lab=VDD}
N 5410 -4300 5410 -3910 {
lab=CLK_OUT}
N 5600 -3920 5600 -3900 {
lab=#net10}
N 5530 -3950 5560 -3950 {
lab=CLK_OUT}
N 5530 -3950 5530 -3870 {
lab=CLK_OUT}
N 5530 -3870 5560 -3870 {
lab=CLK_OUT}
N 5600 -3840 5600 -3820 {
lab=GND}
N 5600 -3870 5620 -3870 {
lab=GND}
N 5620 -3870 5620 -3830 {
lab=GND}
N 5600 -3830 5620 -3830 {
lab=GND}
N 5600 -4000 5600 -3980 {
lab=VDD}
N 5600 -3990 5620 -3990 {
lab=VDD}
N 5620 -3990 5620 -3950 {
lab=VDD}
N 5600 -3950 5620 -3950 {
lab=VDD}
N 5620 -4310 5620 -4290 {
lab=#net9}
N 5550 -4340 5580 -4340 {
lab=CLK_OUT}
N 5550 -4340 5550 -4260 {
lab=CLK_OUT}
N 5550 -4260 5580 -4260 {
lab=CLK_OUT}
N 5620 -4230 5620 -4210 {
lab=GND}
N 5620 -4260 5640 -4260 {
lab=GND}
N 5640 -4260 5640 -4220 {
lab=GND}
N 5620 -4220 5640 -4220 {
lab=GND}
N 5620 -4390 5620 -4370 {
lab=VDD}
N 5620 -4380 5640 -4380 {
lab=VDD}
N 5640 -4380 5640 -4340 {
lab=VDD}
N 5620 -4340 5640 -4340 {
lab=VDD}
N 5410 -4300 5550 -4300 {lab=CLK_OUT}
N 5620 -4300 5820 -4300 {lab=#net9}
N 5410 -3910 5530 -3910 {lab=CLK_OUT}
N 5600 -3910 5780 -3910 {lab=#net10}
N 6300 -3390 6460 -3390 {lab=V_Q_B}
N 6560 -2130 6580 -2130 {lab=CLK_OUT}
N 6820 -2150 6820 -2100 {lab=V_SAWTOOTH}
N 7000 -2380 7000 -2330 {lab=V_ERR_AMP_OUT}
N 6870 -3560 6870 -3520 {
lab=VDD}
N 6870 -3490 6910 -3490 {
lab=VDD}
N 6910 -3540 6910 -3490 {
lab=VDD}
N 6870 -3540 6910 -3540 {
lab=VDD}
N 6870 -3210 6910 -3210 {
lab=GND}
N 6870 -3230 6870 -3180 {
lab=GND}
N 6870 -3260 6910 -3260 {
lab=GND}
N 6910 -3260 6910 -3210 {
lab=GND}
N 6870 -3380 7010 -3380 {
lab=V_FINAL_PWM}
N 6870 -3460 6870 -3290 {
lab=V_FINAL_PWM}
N 6760 -3490 6830 -3490 {lab=V_Q_B}
N 6760 -3490 6760 -3260 {lab=V_Q_B}
N 6760 -3260 6830 -3260 {lab=V_Q_B}
N 6460 -3390 6760 -3390 {lab=V_Q_B}
C {devices/vsource.sym} 7510 -470 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 7510 -420 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 7510 -520 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 7290 -520 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 7230 -1480 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

* .include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.save
+v(s_rst)
+v(clk_swcap)
+v(clk_swcap_d)
+v(v_ctrl_vtc)
+v(vbias1)
+v(vbias2)
+v(vin_p)
+v(v_p)
+v(vd1)
+v(vd2)
+v(amp_mir)
+v(amp_out)
+v(pull_down)
+v(r)
+v(r_b)
+v(s_b)
+v(q_b)
+v(clk_out)
+v(v_sawtooth)
+v(v_err_amp_out)
+v(v_final_pwm)
+v(v_q_b)
+v(v_final_pwm)

.control
  * save all
  * dc V1 0.0 2.0 0.005
  tran 0.05ns 2us
  remzerovec
  write tb_PWM_gen.raw
  set appendwrite

.endc


"
}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -2280 0 0 {name=M1
W=32
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 680 -2280 0 1 {name=M2
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 230 -2420 0 1 {name=M5
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 380 -2570 0 0 {name=M7
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1610 -2040 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 1550 -2150 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 660 -2180 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 210 -2190 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 470 -2570 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1740 -2280 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 210 -2750 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 660 -3060 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 1610 -3060 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 1610 -2210 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 210 -2570 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 230 -2650 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -2960 0 0 {name=M3
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 680 -2960 0 1 {name=M4
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 1770 -2200 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1270 -2100 0 0 {name=M8
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 930 -2100 0 1 {name=M9
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1290 -2000 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 910 -2000 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 910 -3240 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1290 -3240 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1270 -3140 0 0 {name=M10
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 930 -3140 0 1 {name=M11
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1610 -2550 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2030 -2150 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2010 -2050 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2010 -2780 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1990 -2680 0 0 {name=M13
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3740 -2880 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4120 -2880 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2780 0 0 {name=M14
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2780 0 1 {name=M15
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2510 0 0 {name=M16
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2510 0 1 {name=M17
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -1860 0 0 {name=M18
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3740 -1760 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4140 -2080 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1860 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1730 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4120 -1630 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2350 -2780 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2330 -2680 0 0 {name=M25
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -2060 0 1 {name=M27
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -1860 0 1 {name=M28
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2350 -1760 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 2800 -2780 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2680 0 0 {name=M29
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2410 0 0 {name=M30
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -2060 0 0 {name=M31
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -1860 0 0 {name=M32
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2800 -1760 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2280 0 0 {name=M33
W=12
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4430 -2710 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4430 -2630 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4430 -2420 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4430 -2300 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3060 -2190 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 1870 -2610 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3060 -2150 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3060 -1990 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3060 -1940 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 3890 -1860 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 2800 -2560 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 2690 -2560 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 2800 -1960 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 910 -2820 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 770 -2370 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -2070 0 0 {name=M22
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3410 -2420 0 1 {name=M23
W=24
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -1860 0 0 {name=M24
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3390 -1760 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -2070 0 0 {name=M26
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3390 -2520 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 2590 -2410 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1780 -2790 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 1780 -2910 0 1 {name=l28 lab=VDD}
C {devices/gnd.sym} 5630 -1880 0 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5470 -2000 0 1 {name=M38
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5810 -2000 0 0 {name=M39
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2380 0 1 {name=M40
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2380 0 0 {name=M41
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2240 0 1 {name=M42
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2240 0 0 {name=M43
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 6820 -2300 0 0 {name=V2 value=1.4 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 6820 -2270 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 5830 -2140 0 1 {name=p28 lab=AMP_OUT}
C {lab_pin.sym} 5450 -2140 0 0 {name=p29 lab=AMP_MIR}
C {devices/ngspice_get_value.sym} 5470 -1970 2 1 {name=r7 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -1970 2 0 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2210 2 1 {name=r11 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2210 2 0 {name=r12 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2340 2 1 {name=r13 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2340 2 0 {name=r14 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2650 2 0 {name=r22 node=v(@m.xm29.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2380 2 0 {name=r23 node=v(@m.xm30.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2250 2 0 {name=r24 node=v(@m.xm33.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2030 2 0 {name=r25 node=v(@m.xm31.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -1830 2 0 {name=r26 node=v(@m.xm32.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/res_high_po_0p35.sym} 1610 -2150 0 0 {name=R1
L=8
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/ngspice_get_value.sym} 4110 -2750 2 0 {name=r27 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2750 2 1 {name=r28 node=v(@m.xm15.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -1830 2 1 {name=r30 node=v(@m.xm28.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -2030 2 1 {name=r29 node=v(@m.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1700 2 0 {name=r31 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1830 2 0 {name=r32 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4130 -2050 2 1 {name=r33 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -2470 2 0 {name=r34 node=v(@m.xm16.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2470 2 1 {name=r35 node=v(@m.xm17.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -1830 2 0 {name=r36 node=v(@m.xm18.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -2040 2 0 {name=r37 node=v(@m.xm22.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -1830 2 0 {name=r38 node=v(@m.xm24.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -2040 2 0 {name=r39 node=v(@m.xm26.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 4120 -1980 2 1 {name=p35 sig_type=std_logic lab=Vncas_btw}
C {sky130_fd_pr/nfet_01v8.sym} 6100 -2000 0 0 {name=M34
W=20
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6400 -2000 0 0 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6400 -2240 0 0 {name=M36
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6440 -2210 2 1 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6110 -1970 2 0 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6410 -1970 2 0 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6420 -2360 0 0 {name=l33 lab=VDD}
C {lab_wire.sym} 6580 -2130 2 0 {name=p19 sig_type=std_logic lab=CLK_OUT}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -2590 0 0 {name=M49
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5630 -2560 2 0 {name=r18 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5460 -2590 0 0 {name=p30 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 6820 -2380 0 1 {name=p22 lab=V_CTRL_VTC}
C {lab_wire.sym} 6120 -2130 0 0 {name=p23 sig_type=std_logic lab=PULL_DOWN}
C {devices/vdd.sym} 5640 -2710 0 0 {name=l36 lab=VDD}
C {lab_wire.sym} 5560 -2480 0 0 {name=p24 sig_type=std_logic lab=Vp}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -2590 0 0 {name=M52
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6110 -2560 2 0 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5990 -2590 0 0 {name=p31 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6120 -2710 0 0 {name=l34 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 6140 -3550 0 0 {name=M61
L=0.15
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5750 -3310 0 0 {name=M62
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6140 -3090 0 0 {name=M63
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5750 -3550 0 0 {name=M64
L=0.15
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5750 -3090 0 0 {name=M65
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5280 -3550 0 0 {name=M66
L=0.15
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5280 -3090 0 0 {name=M67
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5280 -3310 0 0 {name=M68
L=0.15
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5980 -3310 0 1 {name=M4_c
L=0.15
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5500 -3310 0 1 {name=M7_c
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5220 -3310 0 0 {name=p38 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 5690 -3310 0 0 {name=p39 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 5560 -3310 0 1 {name=p40 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 6040 -3310 0 1 {name=p41 sig_type=std_logic lab=CK1_b}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -4170 3 0 {name=M69
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5850 -4430 1 0 {name=M70
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5830 -3950 0 0 {name=M71
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5830 -3870 0 0 {name=M72
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5960 -4300 0 1 {name=p42 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 5960 -3910 0 1 {name=p43 sig_type=std_logic lab=CK1}
C {sky130_fd_pr/pfet_01v8.sym} 5580 -3950 0 0 {name=M73
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5580 -3870 0 0 {name=M74
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5600 -4340 0 0 {name=M75
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5600 -4260 0 0 {name=M76
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 5330 -4120 2 1 {name=p37 sig_type=std_logic lab=CLK_OUT}
C {devices/vdd.sym} 5850 -4490 0 0 {name=l35 lab=VDD}
C {devices/vdd.sym} 5620 -4390 0 0 {name=l37 lab=VDD}
C {devices/vdd.sym} 5850 -4000 0 0 {name=l38 lab=VDD}
C {devices/vdd.sym} 5600 -4000 0 0 {name=l39 lab=VDD}
C {devices/gnd.sym} 5850 -3820 0 0 {name=l40 lab=GND}
C {devices/gnd.sym} 5600 -3820 0 0 {name=l41 lab=GND}
C {devices/gnd.sym} 5770 -2980 0 0 {name=l42 lab=GND}
C {devices/vdd.sym} 5770 -3650 0 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 5620 -4210 0 0 {name=l44 lab=GND}
C {devices/gnd.sym} 5850 -4100 0 0 {name=l45 lab=GND}
C {lab_pin.sym} 5830 -2300 0 1 {name=p34 lab=VD2}
C {lab_pin.sym} 5450 -2300 0 0 {name=p36 lab=VD1}
C {devices/vsource.sym} 6820 -2070 0 0 {name=V3 value="pwl(0 0 0.2us 1.8 0.2us 0 0.4us 1.8 0.4us 0 0.6us 1.8 0.6us 0 0.8us 1.8 0.8us 0 1.0us 1.8 1.0us 0 1.2us 1.8 1.2us 0 1.4us 1.8 1.4us 0 1.6us 1.8 1.6us 0 1.8us 1.8 1.8us 0 2.0us 1.8)" savecurrent=false
* 0.001 1.4 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)" "pwl(0 0 0.4us 1.8 0.4us 0 0.8us 1.8 0.8us 0 1.2us 1.8 1.2us 0 1.6us 1.8 1.6us 0 2.0us 1.8)"}
C {devices/gnd.sym} 6820 -2040 0 0 {name=V4 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 6820 -2150 0 1 {name=p44 lab=V_SAWTOOTH}
C {devices/vsource.sym} 7000 -2300 0 0 {name=V6 value="pwl(0 1.2 2.0us 0.2)" savecurrent=false
* 0.001 1.4 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)" }
C {devices/gnd.sym} 7000 -2270 0 0 {name=V7 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7000 -2380 0 1 {name=p45 lab=V_ERR_AMP_OUT}
C {lab_pin.sym} 5940 -2380 0 1 {name=p15 lab=V_SAWTOOTH}
C {lab_pin.sym} 5200 -2380 0 0 {name=p25 lab=V_ERR_AMP_OUT}
C {sky130_fd_pr/pfet_01v8.sym} 6850 -3490 0 0 {name=M37
L=0.15
W=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6850 -3260 0 0 {name=M44
L=0.15
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6870 -3560 0 0 {name=l30 lab=VDD}
C {devices/gnd.sym} 6870 -3180 0 0 {name=l31 lab=GND}
C {lab_pin.sym} 7010 -3380 0 1 {name=p26 lab=V_FINAL_PWM}
C {lab_wire.sym} 6400 -3390 2 0 {name=p27 sig_type=std_logic lab=V_Q_B}
