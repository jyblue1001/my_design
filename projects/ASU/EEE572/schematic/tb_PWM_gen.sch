v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 980 -2540 1210 -2380 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.2e-13









color=7
node=v_ref}
B 2 6430 -1350 7090 -900 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.061











color="7 18"
node="clk_swcap


q"}
B 2 5620 -1350 6280 -900 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00013












color=6
node=s_rst}
B 2 6430 -830 7090 -380 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=6
























y1=1.5












color=7
node=v_ctrl_vtc}
B 2 4460 -2130 4720 -1940 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00012












color=6
node=s_rst}
B 2 4460 -1920 4720 -1730 {flags=graph

y2=0.0008
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.00075












color="6 7"
node="i(@m.xm37.msky130_fd_pr__nfet_01v8[id])
i(vmeas)"}
B 2 6030 -1820 6290 -1630 {flags=graph

y2=1.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color=6
node=i(@m.xm34.msky130_fd_pr__nfet_01v8[id])}
B 2 5670 -1820 5930 -1630 {flags=graph

y2=3e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=3e-09












color="6 7"
node="i(@m.xm38.msky130_fd_pr__nfet_01v8[id])
i(@m.xm39.msky130_fd_pr__nfet_01v8[id])"}
B 2 6330 -1820 6590 -1630 {flags=graph

y2=0.00017
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color="6 7 11"
node="i(@m.xm34.msky130_fd_pr__nfet_01v8[id])
i(@m.xm36.msky130_fd_pr__pfet_01v8[id])
i(@m.xm35.msky130_fd_pr__nfet_01v8[id])"}
B 2 6030 -1610 6290 -1420 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.79













color=7
node=pull_down}
B 2 5360 -1820 5620 -1630 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.012













color="7 6"
node="vin_p
v_ctrl_vtc"}
B 2 5670 -1610 5930 -1420 {flags=graph

y2=0.57
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00034














color=7
node=amp_out}
B 2 7930 -2160 8190 -1970 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0













color="7 6"
node="v_sawtooth
v_err_amp_out"}
B 2 8670 -2160 8930 -1970 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.052














color=6
node=v_q_b}
B 2 7930 -2370 8190 -2180 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.09














color=6
node=v_err_amp_out}
B 2 8670 -1940 8930 -1750 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.018














color=7
node=v_final_pwm}
B 2 8220 -2160 8480 -1970 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0018















color=7
node=clk_out}
T {3.1uA} 5690 -2550 0 0 1 1 {}
T {100nA} 6160 -2540 0 0 1 1 {}
T {24/(0.3 * 2)} 5700 -2670 0 0 0.5 0.5 {}
T {24/(0.3 * 8)} 6240 -2680 0 0 0.5 0.5 {}
T {1.0uA} 8960 -3860 0 1 1 1 {}
T {3.1uA} 8320 -3920 0 1 1 1 {}
T {100nA} 7850 -3910 0 1 1 1 {}
T {24/(0.3 * 2)} 8310 -4040 0 1 0.5 0.5 {}
T {24/(0.3 * 8)} 7770 -4050 0 1 0.5 0.5 {}
N 660 -2930 660 -2310 {lab=V_REF_MIR}
N 1610 -2930 1610 -2310 {lab=V_REF}
N 660 -3060 660 -2990 {lab=VDD}
N 1610 -3060 1610 -2990 {lab=VDD}
N 660 -2250 660 -2180 {lab=GND}
N 1610 -2250 1610 -2180 {lab=V_RES}
N 660 -2370 770 -2370 {lab=V_REF_MIR}
N 770 -2370 770 -2280 {lab=V_REF_MIR}
N 1610 -2960 1650 -2960 {lab=VDD}
N 1650 -3020 1650 -2960 {lab=VDD}
N 1610 -3020 1650 -3020 {lab=VDD}
N 620 -2960 660 -2960 {lab=VDD}
N 620 -3020 620 -2960 {lab=VDD}
N 620 -3020 660 -3020 {lab=VDD}
N 620 -2220 660 -2220 {lab=GND}
N 620 -2280 620 -2220 {lab=GND}
N 620 -2280 660 -2280 {lab=GND}
N 1610 -2280 1740 -2280 {lab=GND}
N 210 -2620 210 -2450 {lab=START_UP}
N 210 -2750 210 -2680 {lab=VDD}
N 170 -2650 210 -2650 {lab=VDD}
N 170 -2710 170 -2650 {lab=VDD}
N 170 -2710 210 -2710 {lab=VDD}
N 170 -2420 170 -2360 {lab=GND}
N 170 -2420 210 -2420 {lab=GND}
N 400 -2570 470 -2570 {lab=GND}
N 210 -2570 360 -2570 {lab=START_UP}
N 250 -2650 280 -2650 {lab=START_UP}
N 280 -2650 280 -2570 {lab=START_UP}
N 400 -2610 400 -2600 {lab=Vbiasp}
N 400 -2540 400 -2530 {lab=V_REF_MIR}
N 400 -2530 660 -2530 {lab=V_REF_MIR}
N 1550 -2150 1590 -2150 {lab=GND}
N 1610 -2120 1610 -2040 {lab=GND}
N 250 -2420 660 -2420 {lab=V_REF_MIR}
N 210 -2390 210 -2310 {lab=GND}
N 210 -2310 210 -2190 {lab=GND}
N 170 -2360 210 -2360 {lab=GND}
N 910 -3110 910 -2130 {lab=Vbiasp_MIR}
N 1290 -3110 1290 -2130 {lab=Vbiasp}
N 950 -3140 1250 -3140 {lab=Vbiasp_MIR}
N 910 -3240 910 -3170 {lab=VDD}
N 1290 -3240 1290 -3170 {lab=VDD}
N 910 -2070 910 -2000 {lab=GND}
N 1290 -2070 1290 -2000 {lab=GND}
N 1290 -3140 1330 -3140 {lab=VDD}
N 1330 -3200 1330 -3140 {lab=VDD}
N 1290 -3200 1330 -3200 {lab=VDD}
N 870 -3140 910 -3140 {lab=VDD}
N 870 -3200 870 -3140 {lab=VDD}
N 870 -3200 910 -3200 {lab=VDD}
N 870 -2040 910 -2040 {lab=GND}
N 870 -2100 870 -2040 {lab=GND}
N 870 -2100 910 -2100 {lab=GND}
N 1290 -2040 1330 -2040 {lab=GND}
N 1330 -2100 1330 -2040 {lab=GND}
N 1290 -2100 1330 -2100 {lab=GND}
N 1090 -3140 1090 -3030 {lab=Vbiasp_MIR}
N 910 -3030 1090 -3030 {lab=Vbiasp_MIR}
N 700 -2280 770 -2280 {lab=V_REF_MIR}
N 770 -2280 1120 -2280 {lab=V_REF_MIR}
N 1120 -2280 1250 -2100 {lab=V_REF_MIR}
N 950 -2100 1190 -2280 {lab=V_REF}
N 1190 -2280 1570 -2280 {lab=V_REF}
N 1490 -2370 1490 -2280 {lab=V_REF}
N 1490 -2370 1610 -2370 {lab=V_REF}
N 700 -2960 1290 -2960 {lab=Vbiasp}
N 1290 -2960 1570 -2960 {lab=Vbiasp}
N 400 -2610 1290 -2610 {lab=Vbiasp}
N 2010 -2120 2010 -2050 {lab=GND}
N 1970 -2090 2010 -2090 {lab=GND}
N 1970 -2150 1970 -2090 {lab=GND}
N 1970 -2150 2010 -2150 {lab=GND}
N 2010 -2780 2010 -2710 {lab=VDD}
N 2010 -2680 2050 -2680 {lab=VDD}
N 2050 -2740 2050 -2680 {lab=VDD}
N 2010 -2740 2050 -2740 {lab=VDD}
N 2010 -2650 2010 -2180 {lab=Vbias3}
N 3780 -2780 4080 -2780 {lab=Vbias1}
N 3740 -2880 3740 -2810 {lab=VDD}
N 4120 -2880 4120 -2810 {lab=VDD}
N 4120 -2780 4160 -2780 {lab=VDD}
N 4160 -2840 4160 -2780 {lab=VDD}
N 4120 -2840 4160 -2840 {lab=VDD}
N 3700 -2780 3740 -2780 {lab=VDD}
N 3700 -2840 3700 -2780 {lab=VDD}
N 3700 -2840 3740 -2840 {lab=VDD}
N 3920 -2780 3920 -2670 {lab=Vbias1}
N 3740 -2330 3920 -2330 {lab=Vbias1}
N 3780 -2510 4080 -2510 {lab=Vbias2}
N 3740 -2610 3740 -2540 {lab=Vhigh}
N 4120 -2610 4120 -2540 {lab=#net1}
N 4120 -2510 4160 -2510 {lab=VDD}
N 4160 -2570 4160 -2510 {lab=VDD}
N 3700 -2510 3740 -2510 {lab=VDD}
N 3700 -2570 3700 -2510 {lab=VDD}
N 3740 -2750 3740 -2610 {lab=Vhigh}
N 4120 -2750 4120 -2610 {lab=#net1}
N 3920 -2670 3920 -2330 {lab=Vbias1}
N 3740 -2480 3740 -2260 {lab=Vbias1}
N 4120 -2480 4120 -2260 {lab=Vncas}
N 3640 -2420 3840 -2420 {lab=Vbias2}
N 3840 -2510 3840 -2420 {lab=Vbias2}
N 3740 -1830 3740 -1760 {lab=GND}
N 3740 -1800 3780 -1800 {lab=GND}
N 3780 -1860 3780 -1800 {lab=GND}
N 3740 -1860 3780 -1860 {lab=GND}
N 3740 -1950 3740 -1890 {lab=#net2}
N 3550 -1860 3700 -1860 {lab=Vbias4}
N 4120 -2050 4120 -1980 {lab=Vncas_btw}
N 4080 -2080 4080 -2020 {lab=GND}
N 4080 -2080 4120 -2080 {lab=GND}
N 4120 -2260 4120 -2110 {lab=Vncas}
N 4120 -2300 4430 -2300 {lab=Vncas}
N 4160 -2080 4250 -2080 {lab=Vncas}
N 4120 -1830 4120 -1760 {lab=#net3}
N 4160 -1860 4160 -1800 {lab=GND}
N 4120 -1860 4160 -1860 {lab=GND}
N 4120 -1980 4120 -1890 {lab=Vncas_btw}
N 4120 -1700 4120 -1630 {lab=GND}
N 4120 -1670 4160 -1670 {lab=GND}
N 4160 -1730 4160 -1670 {lab=GND}
N 4120 -1730 4160 -1730 {lab=GND}
N 3990 -1730 4080 -1730 {lab=Vncas_btw}
N 4080 -2020 4160 -2020 {lab=GND}
N 4160 -2020 4160 -1860 {lab=GND}
N 4160 -1800 4160 -1730 {lab=GND}
N 3990 -1940 3990 -1730 {lab=Vncas_btw}
N 3990 -1940 4120 -1940 {lab=Vncas_btw}
N 3700 -2780 3700 -2570 {lab=VDD}
N 4160 -2780 4160 -2570 {lab=VDD}
N 2350 -2780 2350 -2710 {lab=VDD}
N 2350 -2680 2390 -2680 {lab=VDD}
N 2390 -2740 2390 -2680 {lab=VDD}
N 2350 -2740 2390 -2740 {lab=VDD}
N 2350 -2510 2350 -2440 {lab=Vbias4}
N 2350 -2650 2350 -2510 {lab=Vbias4}
N 2350 -2380 2350 -2160 {lab=Vbias4}
N 2310 -2060 2310 -2000 {lab=GND}
N 2350 -2160 2350 -2090 {lab=Vbias4}
N 2310 -2060 2350 -2060 {lab=GND}
N 2350 -2030 2350 -1960 {lab=Vlow}
N 3920 -2710 4430 -2710 {lab=Vbias1}
N 2200 -2680 2200 -2610 {lab=Vbiasp}
N 2200 -2680 2310 -2680 {lab=Vbiasp}
N 2310 -1860 2310 -1800 {lab=GND}
N 2350 -1960 2350 -1890 {lab=Vlow}
N 2310 -1860 2350 -1860 {lab=GND}
N 2350 -1830 2350 -1760 {lab=GND}
N 2310 -1800 2350 -1800 {lab=GND}
N 2390 -1860 2470 -1860 {lab=Vbias4}
N 2470 -2220 2470 -1860 {lab=Vbias4}
N 2350 -2220 2470 -2220 {lab=Vbias4}
N 3840 -2420 4430 -2420 {lab=Vbias2}
N 4250 -2300 4250 -2080 {lab=Vncas}
N 2310 -2000 2310 -1860 {lab=GND}
N 2800 -2780 2800 -2710 {lab=VDD}
N 2800 -2680 2840 -2680 {lab=VDD}
N 2840 -2740 2840 -2680 {lab=VDD}
N 2800 -2740 2840 -2740 {lab=VDD}
N 2800 -2510 2800 -2440 {lab=Vds2}
N 2800 -2410 2840 -2410 {lab=VDD}
N 2840 -2470 2840 -2410 {lab=VDD}
N 2800 -2650 2800 -2510 {lab=Vds2}
N 2840 -2060 2840 -2000 {lab=GND}
N 2800 -2160 2800 -2090 {lab=Vpcas}
N 2840 -2680 2840 -2470 {lab=VDD}
N 2800 -2060 2840 -2060 {lab=GND}
N 2800 -2030 2800 -1960 {lab=Vds3}
N 2690 -2680 2690 -2610 {lab=Vgs2}
N 2690 -2680 2760 -2680 {lab=Vgs2}
N 2840 -1860 2840 -1800 {lab=GND}
N 2800 -1960 2800 -1890 {lab=Vds3}
N 2800 -1860 2840 -1860 {lab=GND}
N 2800 -1830 2800 -1760 {lab=GND}
N 2800 -1800 2840 -1800 {lab=GND}
N 2680 -1860 2760 -1860 {lab=Vbias4}
N 2590 -2410 2760 -2410 {lab=Vbias2}
N 2840 -2000 2840 -1860 {lab=GND}
N 2470 -1860 2680 -1860 {lab=Vbias4}
N 2390 -2060 2760 -2060 {lab=Vbias3}
N 2590 -2150 2590 -2060 {lab=Vbias3}
N 2800 -2280 2840 -2280 {lab=VDD}
N 2840 -2340 2840 -2280 {lab=VDD}
N 2690 -2280 2690 -2190 {lab=Vpcas}
N 2690 -2280 2760 -2280 {lab=Vpcas}
N 2840 -2410 2840 -2340 {lab=VDD}
N 2800 -2380 2800 -2310 {lab=Vgs2}
N 2690 -2610 2690 -2350 {lab=Vgs2}
N 2690 -2350 2800 -2350 {lab=Vgs2}
N 2800 -2250 2800 -2160 {lab=Vpcas}
N 2690 -2190 2800 -2190 {lab=Vpcas}
N 2800 -2190 3060 -2190 {lab=Vpcas}
N 3890 -1860 4080 -1860 {lab=Vbias3}
N 1870 -2610 1900 -2610 {lab=Vbiasp}
N 2590 -2150 3060 -2150 {lab=Vbias3}
N 2350 -1990 3060 -1990 {lab=Vlow}
N 2470 -1940 3060 -1940 {lab=Vbias4}
N 3740 -2630 4430 -2630 {lab=Vhigh}
N 1460 -2960 1460 -2870 {lab=Vbiasp}
N 1890 -2680 1970 -2680 {lab=Vbiasp}
N 1460 -2680 1890 -2680 {lab=Vbiasp}
N 1460 -2870 1460 -2680 {lab=Vbiasp}
N 2350 -2440 2350 -2380 {lab=Vbias4}
N 2050 -2150 2260 -2150 {lab=Vbias3}
N 2120 -2260 2120 -2150 {lab=Vbias3}
N 2010 -2260 2120 -2260 {lab=Vbias3}
N 1900 -2610 2200 -2610 {lab=Vbiasp}
N 1870 -2680 1870 -2610 {lab=Vbiasp}
N 2260 -2150 2590 -2150 {lab=Vbias3}
N 3740 -2040 3740 -1950 {lab=#net2}
N 3740 -2070 3780 -2070 {lab=GND}
N 3740 -2260 3740 -2100 {lab=Vbias1}
N 3780 -2070 3780 -1860 {lab=GND}
N 3550 -2070 3700 -2070 {lab=Vbias3}
N 3350 -2420 3390 -2420 {lab=VDD}
N 3390 -2390 3390 -2260 {lab=Vbias2}
N 3390 -1830 3390 -1760 {lab=GND}
N 3390 -1800 3430 -1800 {lab=GND}
N 3430 -1860 3430 -1800 {lab=GND}
N 3390 -1860 3430 -1860 {lab=GND}
N 3390 -1950 3390 -1890 {lab=#net4}
N 3200 -1860 3350 -1860 {lab=Vbias4}
N 3390 -2040 3390 -1950 {lab=#net4}
N 3390 -2070 3430 -2070 {lab=GND}
N 3390 -2260 3390 -2100 {lab=Vbias2}
N 3430 -2070 3430 -1860 {lab=GND}
N 3200 -2070 3350 -2070 {lab=Vbias3}
N 3390 -2520 3390 -2450 {lab=VDD}
N 3350 -2480 3350 -2420 {lab=VDD}
N 3350 -2480 3390 -2480 {lab=VDD}
N 3430 -2420 3640 -2420 {lab=Vbias2}
N 3480 -2420 3480 -2330 {lab=Vbias2}
N 3390 -2330 3480 -2330 {lab=Vbias2}
N 3060 -2150 3200 -2150 {lab=Vbias3}
N 3200 -2150 3200 -2070 {lab=Vbias3}
N 3060 -1940 3200 -1940 {lab=Vbias4}
N 3200 -1940 3200 -1860 {lab=Vbias4}
N 3550 -2150 3550 -2070 {lab=Vbias3}
N 3550 -1940 3550 -1860 {lab=Vbias4}
N 3200 -1940 3550 -1940 {lab=Vbias4}
N 3200 -2150 3550 -2150 {lab=Vbias3}
N 3550 -2150 3890 -2150 {lab=Vbias3}
N 3890 -2150 3890 -1860 {lab=Vbias3}
N 1780 -2910 1780 -2820 {lab=VDD}
N 1780 -2760 1780 -2680 {lab=Vbiasp}
N 5490 -2000 5790 -2000 {lab=AMP_MIR}
N 5450 -2480 5450 -2410 {lab=Vp}
N 5830 -2480 5830 -2410 {lab=Vp}
N 5450 -2350 5450 -2270 {lab=VD1}
N 5830 -2350 5830 -2270 {lab=VD2}
N 5830 -2210 5830 -2030 {lab=AMP_OUT}
N 5450 -2210 5450 -2030 {lab=AMP_MIR}
N 5450 -1900 5830 -1900 {lab=GND}
N 5630 -1900 5630 -1870 {lab=GND}
N 5350 -2380 5410 -2380 {lab=V_ERR_AMP_OUT}
N 5870 -2380 5940 -2380 {lab=V_SAWTOOTH}
N 6820 -2380 6820 -2330 {lab=V_CTRL_VTC}
N 5450 -2080 5630 -2080 {lab=AMP_MIR}
N 5630 -2080 5630 -2000 {lab=AMP_MIR}
N 5380 -2000 5380 -1900 {lab=GND}
N 5380 -1900 5450 -1900 {lab=GND}
N 5380 -2000 5450 -2000 {lab=GND}
N 5900 -2000 5900 -1900 {lab=GND}
N 5830 -1900 5900 -1900 {lab=GND}
N 5830 -2000 5900 -2000 {lab=GND}
N 5380 -2240 5380 -2000 {lab=GND}
N 5900 -2240 5900 -2000 {lab=GND}
N 5450 -2240 5830 -2240 {lab=VDD}
N 5450 -2380 5830 -2380 {lab=VDD}
N 5680 -2380 5680 -2240 {lab=VDD}
N 5450 -1970 5450 -1900 {lab=GND}
N 5830 -1970 5830 -1900 {lab=GND}
N 6160 -2000 6160 -1900 {lab=GND}
N 6120 -1900 6160 -1900 {lab=GND}
N 6120 -2000 6160 -2000 {lab=GND}
N 6120 -1970 6120 -1900 {lab=GND}
N 6460 -2000 6460 -1900 {lab=GND}
N 6420 -1900 6460 -1900 {lab=GND}
N 6420 -2000 6460 -2000 {lab=GND}
N 6420 -1970 6420 -1900 {lab=GND}
N 5950 -2080 5950 -2000 {lab=AMP_OUT}
N 5950 -2000 6080 -2000 {lab=AMP_OUT}
N 6120 -2560 6120 -2030 {lab=PULL_DOWN}
N 6330 -2080 6330 -2000 {lab=PULL_DOWN}
N 6330 -2000 6380 -2000 {lab=PULL_DOWN}
N 6420 -2210 6420 -2030 {lab=CLK_OUT}
N 6330 -2240 6330 -2080 {lab=PULL_DOWN}
N 6330 -2240 6380 -2240 {lab=PULL_DOWN}
N 6120 -2130 6330 -2130 {lab=PULL_DOWN}
N 6460 -2310 6460 -2240 {lab=VDD}
N 6420 -2240 6460 -2240 {lab=VDD}
N 6420 -2310 6420 -2270 {lab=VDD}
N 6420 -2310 6460 -2310 {lab=VDD}
N 6420 -2360 6420 -2310 {lab=VDD}
N 5450 -2480 5830 -2480 {lab=Vp}
N 5640 -2560 5640 -2480 {lab=Vp}
N 6420 -2130 6560 -2130 {lab=CLK_OUT}
N 5380 -2240 5410 -2240 {lab=GND}
N 5870 -2240 5900 -2240 {lab=GND}
N 5900 -1900 6120 -1900 {lab=GND}
N 6160 -1900 6420 -1900 {lab=GND}
N 5640 -2590 5680 -2590 {lab=VDD}
N 5560 -2590 5600 -2590 {lab=Vbias1}
N 5460 -2590 5560 -2590 {lab=Vbias1}
N 5200 -2380 5350 -2380 {lab=V_ERR_AMP_OUT}
N 5680 -2590 5680 -2380 {lab=VDD}
N 5640 -2670 5680 -2670 {lab=VDD}
N 5640 -2710 5640 -2620 {lab=VDD}
N 5680 -2670 5680 -2590 {lab=VDD}
N 6120 -2590 6160 -2590 {lab=VDD}
N 6040 -2590 6080 -2590 {lab=Vbias1}
N 5990 -2590 6040 -2590 {lab=Vbias1}
N 6120 -2670 6160 -2670 {lab=VDD}
N 6160 -2670 6160 -2590 {lab=VDD}
N 6120 -2710 6120 -2620 {lab=VDD}
N 5830 -2080 5950 -2080 {lab=AMP_OUT}
N 7510 -520 7510 -500 {lab=VDD}
N 7510 -440 7510 -420 {lab=GND}
N 6560 -2130 6580 -2130 {lab=CLK_OUT}
N 7000 -2380 7000 -2330 {lab=V_ERR_AMP_OUT}
N 5940 -3130 5940 -3060 {lab=GNDA}
N 5940 -3100 5980 -3100 {lab=GNDA}
N 5980 -3160 5980 -3100 {lab=GNDA}
N 5940 -3160 5980 -3160 {lab=GNDA}
N 5980 -3300 5980 -3240 {lab=GNDA}
N 5940 -3300 5980 -3300 {lab=GNDA}
N 5940 -3270 5940 -3190 {lab=V_tail_btw}
N 5980 -3240 5980 -3160 {lab=GNDA}
N 5800 -3640 6100 -3640 {lab=Vb1}
N 5800 -4020 6100 -4020 {lab=ERR_AMP_MIR}
N 5760 -4120 5760 -4050 {lab=VDDA}
N 6140 -4120 6140 -4050 {lab=VDDA}
N 6140 -4020 6180 -4020 {lab=VDDA}
N 6180 -4080 6180 -4020 {lab=VDDA}
N 6140 -4080 6180 -4080 {lab=VDDA}
N 5720 -4020 5760 -4020 {lab=VDDA}
N 5720 -4080 5720 -4020 {lab=VDDA}
N 5720 -4080 5760 -4080 {lab=VDDA}
N 5800 -3880 6100 -3880 {lab=Vbias2}
N 6140 -3880 6180 -3880 {lab=VDDA}
N 5720 -3880 5760 -3880 {lab=VDDA}
N 5720 -4020 5720 -3880 {lab=VDDA}
N 6180 -4020 6180 -3880 {lab=VDDA}
N 5760 -3610 5760 -3510 {lab=Vd1}
N 6140 -3610 6140 -3510 {lab=Vd2}
N 5760 -3990 5760 -3910 {lab=#net5}
N 6140 -3990 6140 -3910 {lab=#net6}
N 6140 -3850 6140 -3670 {lab=ERR_AMP_OUT}
N 5760 -3850 5760 -3670 {lab=ERR_AMP_MIR}
N 5680 -3640 5760 -3640 {lab=GND}
N 6140 -3640 6220 -3640 {lab=GND}
N 5760 -3450 5760 -3390 {lab=Vp}
N 5760 -3390 6140 -3390 {lab=Vp}
N 6140 -3450 6140 -3390 {lab=Vp}
N 5940 -3390 5940 -3330 {lab=Vp}
N 5980 -3480 5980 -3300 {lab=GNDA}
N 5980 -3480 6140 -3480 {lab=GNDA}
N 5760 -3480 5980 -3480 {lab=GNDA}
N 5940 -3520 5940 -3390 {lab=Vp}
N 5940 -3550 5980 -3550 {lab=GNDA}
N 5980 -3550 5980 -3480 {lab=GNDA}
N 5940 -3640 5940 -3580 {lab=Vb1}
N 5870 -3550 5900 -3550 {lab=Vb1}
N 5870 -3600 5870 -3550 {lab=Vb1}
N 5870 -3600 5940 -3600 {lab=Vb1}
N 5590 -3480 5720 -3480 {lab=VIN_P}
N 6180 -3480 6310 -3480 {lab=VIN_M}
N 5760 -3700 5840 -3700 {lab=ERR_AMP_MIR}
N 5840 -4020 5840 -3700 {lab=ERR_AMP_MIR}
N 6010 -4090 6050 -4090 {lab=VDDA}
N 6010 -3780 6050 -3780 {lab=VDDA}
N 6010 -4060 6010 -3810 {lab=#net7}
N 6050 -4090 6050 -3780 {lab=VDDA}
N 6010 -3750 6010 -3640 {lab=Vb1}
N 6010 -4190 6010 -4120 {lab=VDDA}
N 6050 -4150 6050 -4090 {lab=VDDA}
N 6010 -4150 6050 -4150 {lab=VDDA}
N 5930 -3780 5970 -3780 {lab=Vbias2}
N 5930 -3880 5930 -3780 {lab=Vbias2}
N 5890 -4090 5970 -4090 {lab=Vbias1}
N 5770 -3300 5900 -3300 {lab=Vbias3}
N 5770 -3160 5900 -3160 {lab=Vbias4}
N 6140 -3750 6640 -3750 {lab=ERR_AMP_OUT}
N 8220 -3370 8520 -3370 {lab=AMP_MIR}
N 8560 -3850 8560 -3780 {lab=Vp}
N 8180 -3850 8180 -3780 {lab=Vp}
N 8560 -3720 8560 -3640 {lab=VD1}
N 8180 -3720 8180 -3640 {lab=VD2}
N 8180 -3580 8180 -3400 {lab=AMP_OUT}
N 8560 -3580 8560 -3400 {lab=AMP_MIR}
N 8180 -3270 8560 -3270 {lab=GND}
N 8380 -3270 8380 -3240 {lab=GND}
N 8600 -3750 8660 -3750 {lab=VIN_P}
N 8070 -3750 8140 -3750 {lab=V_CTRL_VTC}
N 8380 -3450 8560 -3450 {lab=AMP_MIR}
N 8380 -3450 8380 -3370 {lab=AMP_MIR}
N 8630 -3370 8630 -3270 {lab=GND}
N 8560 -3270 8630 -3270 {lab=GND}
N 8560 -3370 8630 -3370 {lab=GND}
N 8110 -3370 8110 -3270 {lab=GND}
N 8110 -3270 8180 -3270 {lab=GND}
N 8110 -3370 8180 -3370 {lab=GND}
N 8630 -3610 8630 -3370 {lab=GND}
N 8110 -3610 8110 -3370 {lab=GND}
N 8180 -3610 8560 -3610 {lab=VDD}
N 8180 -3750 8560 -3750 {lab=VDD}
N 8330 -3750 8330 -3610 {lab=VDD}
N 8560 -3340 8560 -3270 {lab=GND}
N 8180 -3340 8180 -3270 {lab=GND}
N 7850 -3370 7850 -3270 {lab=GND}
N 7850 -3270 7890 -3270 {lab=GND}
N 7850 -3370 7890 -3370 {lab=GND}
N 7890 -3340 7890 -3270 {lab=GND}
N 7550 -3370 7550 -3270 {lab=GND}
N 7550 -3270 7590 -3270 {lab=GND}
N 7550 -3370 7590 -3370 {lab=GND}
N 7590 -3340 7590 -3270 {lab=GND}
N 8060 -3450 8060 -3370 {lab=AMP_OUT}
N 7930 -3370 8060 -3370 {lab=AMP_OUT}
N 7890 -3930 7890 -3400 {lab=PULL_DOWN}
N 7680 -3450 7680 -3370 {lab=PULL_DOWN}
N 7630 -3370 7680 -3370 {lab=PULL_DOWN}
N 7590 -3580 7590 -3400 {lab=S_RST}
N 7680 -3610 7680 -3450 {lab=PULL_DOWN}
N 7630 -3610 7680 -3610 {lab=PULL_DOWN}
N 7680 -3500 7890 -3500 {lab=PULL_DOWN}
N 7550 -3680 7550 -3610 {lab=VDD}
N 7550 -3610 7590 -3610 {lab=VDD}
N 7590 -3680 7590 -3640 {lab=VDD}
N 7550 -3680 7590 -3680 {lab=VDD}
N 7590 -3730 7590 -3680 {lab=VDD}
N 8180 -3850 8560 -3850 {lab=Vp}
N 8370 -3930 8370 -3850 {lab=Vp}
N 7450 -3500 7590 -3500 {lab=S_RST}
N 8600 -3610 8630 -3610 {lab=GND}
N 8110 -3610 8140 -3610 {lab=GND}
N 8870 -3470 8870 -3370 {lab=GND}
N 7890 -3270 8110 -3270 {lab=GND}
N 7590 -3270 7850 -3270 {lab=GND}
N 9070 -3430 9110 -3430 {lab=GND}
N 9110 -3470 9110 -3430 {lab=GND}
N 8870 -3430 9070 -3430 {lab=GND}
N 8870 -3660 9110 -3660 {lab=VIN_P}
N 9110 -3660 9110 -3530 {lab=VIN_P}
N 9150 -3500 9260 -3500 {lab=S_RST}
N 9020 -3730 9020 -3660 {lab=VIN_P}
N 8980 -3760 9020 -3760 {lab=VDD}
N 9060 -3760 9100 -3760 {lab=Vbias1}
N 8980 -3830 8980 -3760 {lab=VDD}
N 9100 -3760 9200 -3760 {lab=Vbias1}
N 8330 -3960 8370 -3960 {lab=VDD}
N 8410 -3960 8450 -3960 {lab=Vbias1}
N 8450 -3960 8550 -3960 {lab=Vbias1}
N 7430 -3500 7430 -3220 {lab=S_RST}
N 8810 -3660 8870 -3660 {lab=VIN_P}
N 8810 -3750 8810 -3660 {lab=VIN_P}
N 8660 -3750 8810 -3750 {lab=VIN_P}
N 9020 -3880 9020 -3790 {lab=#net8}
N 9020 -3500 9110 -3500 {lab=GND}
N 8330 -3960 8330 -3750 {lab=VDD}
N 8330 -4040 8370 -4040 {lab=VDD}
N 8370 -4080 8370 -3990 {lab=VDD}
N 8330 -4040 8330 -3960 {lab=VDD}
N 8980 -3990 9020 -3990 {lab=VDD}
N 8980 -3910 9020 -3910 {lab=VDD}
N 9110 -3910 9110 -3760 {lab=Vbias1}
N 9060 -3910 9110 -3910 {lab=Vbias1}
N 8980 -3990 8980 -3910 {lab=VDD}
N 9020 -4030 9020 -3940 {lab=VDD}
N 7850 -3960 7890 -3960 {lab=VDD}
N 7930 -3960 7970 -3960 {lab=Vbias1}
N 7970 -3960 8020 -3960 {lab=Vbias1}
N 7850 -4040 7890 -4040 {lab=VDD}
N 7850 -4040 7850 -3960 {lab=VDD}
N 7890 -4080 7890 -3990 {lab=VDD}
N 8870 -3570 8870 -3530 {lab=#net9}
N 8870 -3660 8870 -3630 {lab=VIN_P}
N 9260 -3420 9260 -3220 {lab=S_RST}
N 9260 -3500 9260 -3420 {lab=S_RST}
N 7780 -3220 9260 -3220 {lab=S_RST}
N 7430 -3220 7780 -3220 {lab=S_RST}
N 8060 -3450 8180 -3450 {lab=AMP_OUT}
N 7430 -3500 7450 -3500 {lab=S_RST}
N 8980 -3910 8980 -3830 {lab=VDD}
C {devices/vsource.sym} 7510 -470 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 7510 -420 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 7510 -520 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 7290 -520 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 9440 -3780 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

* .include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.save
+v(s_rst)
+v(clk_swcap)
+v(clk_swcap_d)
+v(v_ctrl_vtc)
+v(vbias1)
+v(vbias2)
+v(vin_p)
+v(v_p)
+v(vd1)
+v(vd2)
+v(amp_mir)
+v(amp_out)
+v(pull_down)
+v(sawtooth_v_p)
+v(sawtooth_vd1)
+v(sawtooth_vd2)
+v(sawtooth_amp_mir)
+v(sawtooth_amp_out)
+v(sawtooth_pull_down)
+v(v_sawtooth)
+v(err_amp_mir)
+v(err_amp_out)
+v(clk_out)
+v(v_sawtooth)
+v(v_err_amp_out)


.control
  * save all
  * dc V1 0.0 2.0 0.005
  tran 0.05ns 2us
  remzerovec
  write tb_PWM_gen.raw
  set appendwrite

.endc


"
}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -2280 0 0 {name=M1
W=32
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 680 -2280 0 1 {name=M2
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 230 -2420 0 1 {name=M5
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 380 -2570 0 0 {name=M7
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1610 -2040 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 1550 -2150 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 660 -2180 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 210 -2190 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 470 -2570 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1740 -2280 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 210 -2750 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 660 -3060 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 1610 -3060 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 1610 -2210 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 210 -2570 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 230 -2650 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -2960 0 0 {name=M3
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 680 -2960 0 1 {name=M4
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 1770 -2200 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1270 -2100 0 0 {name=M8
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 930 -2100 0 1 {name=M9
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1290 -2000 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 910 -2000 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 910 -3240 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1290 -3240 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1270 -3140 0 0 {name=M10
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 930 -3140 0 1 {name=M11
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1610 -2550 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2030 -2150 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2010 -2050 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2010 -2780 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1990 -2680 0 0 {name=M13
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3740 -2880 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4120 -2880 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2780 0 0 {name=M14
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2780 0 1 {name=M15
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2510 0 0 {name=M16
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2510 0 1 {name=M17
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -1860 0 0 {name=M18
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3740 -1760 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4140 -2080 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1860 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1730 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4120 -1630 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2350 -2780 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2330 -2680 0 0 {name=M25
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -2060 0 1 {name=M27
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -1860 0 1 {name=M28
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2350 -1760 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 2800 -2780 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2680 0 0 {name=M29
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2410 0 0 {name=M30
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -2060 0 0 {name=M31
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -1860 0 0 {name=M32
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2800 -1760 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2280 0 0 {name=M33
W=12
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4430 -2710 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4430 -2630 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4430 -2420 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4430 -2300 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3060 -2190 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 1870 -2610 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3060 -2150 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3060 -1990 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3060 -1940 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 3890 -1860 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 2800 -2560 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 2690 -2560 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 2800 -1960 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 910 -2820 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 770 -2370 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -2070 0 0 {name=M22
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3410 -2420 0 1 {name=M23
W=24
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -1860 0 0 {name=M24
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3390 -1760 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -2070 0 0 {name=M26
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3390 -2520 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 2590 -2410 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1780 -2790 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 1780 -2910 0 1 {name=l28 lab=VDD}
C {devices/gnd.sym} 5630 -1880 0 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5470 -2000 0 1 {name=M38
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5810 -2000 0 0 {name=M39
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2380 0 1 {name=M40
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2380 0 0 {name=M41
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2240 0 1 {name=M42
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2240 0 0 {name=M43
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 6820 -2300 0 0 {name=V2 value=1.4 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 6820 -2270 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 5830 -2140 0 1 {name=p28 lab=AMP_OUT}
C {lab_pin.sym} 5450 -2140 0 0 {name=p29 lab=AMP_MIR}
C {devices/ngspice_get_value.sym} 5470 -1970 2 1 {name=r7 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -1970 2 0 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2210 2 1 {name=r11 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2210 2 0 {name=r12 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2340 2 1 {name=r13 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2340 2 0 {name=r14 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2650 2 0 {name=r22 node=v(@m.xm29.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2380 2 0 {name=r23 node=v(@m.xm30.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2250 2 0 {name=r24 node=v(@m.xm33.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2030 2 0 {name=r25 node=v(@m.xm31.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -1830 2 0 {name=r26 node=v(@m.xm32.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/res_high_po_0p35.sym} 1610 -2150 0 0 {name=R1
L=8
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/ngspice_get_value.sym} 4110 -2750 2 0 {name=r27 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2750 2 1 {name=r28 node=v(@m.xm15.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -1830 2 1 {name=r30 node=v(@m.xm28.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -2030 2 1 {name=r29 node=v(@m.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1700 2 0 {name=r31 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1830 2 0 {name=r32 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4130 -2050 2 1 {name=r33 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -2470 2 0 {name=r34 node=v(@m.xm16.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2470 2 1 {name=r35 node=v(@m.xm17.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -1830 2 0 {name=r36 node=v(@m.xm18.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -2040 2 0 {name=r37 node=v(@m.xm22.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -1830 2 0 {name=r38 node=v(@m.xm24.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -2040 2 0 {name=r39 node=v(@m.xm26.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 4120 -1980 2 1 {name=p35 sig_type=std_logic lab=Vncas_btw}
C {sky130_fd_pr/nfet_01v8.sym} 6100 -2000 0 0 {name=M34
W=20
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6400 -2000 0 0 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6400 -2240 0 0 {name=M36
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6440 -2210 2 1 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6110 -1970 2 0 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6410 -1970 2 0 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6420 -2360 0 0 {name=l33 lab=VDD}
C {lab_wire.sym} 6580 -2130 2 0 {name=p19 sig_type=std_logic lab=CLK_OUT}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -2590 0 0 {name=M49
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5630 -2560 2 0 {name=r18 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5460 -2590 0 0 {name=p30 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 6820 -2380 0 1 {name=p22 lab=V_CTRL_VTC}
C {lab_wire.sym} 6120 -2130 0 0 {name=p23 sig_type=std_logic lab=PULL_DOWN}
C {devices/vdd.sym} 5640 -2710 0 0 {name=l36 lab=VDD}
C {lab_wire.sym} 5560 -2480 0 0 {name=p24 sig_type=std_logic lab=Vp}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -2590 0 0 {name=M52
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6110 -2560 2 0 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5990 -2590 0 0 {name=p31 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6120 -2710 0 0 {name=l34 lab=VDD}
C {lab_pin.sym} 5830 -2300 0 1 {name=p34 lab=VD2}
C {lab_pin.sym} 5450 -2300 0 0 {name=p36 lab=VD1}
C {devices/vsource.sym} 7000 -2300 0 0 {name=V6 value="pwl(0 1.2 2.0us 0.2)" savecurrent=false
* 0.001 1.4 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)" }
C {devices/gnd.sym} 7000 -2270 0 0 {name=V7 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7000 -2380 0 1 {name=p45 lab=V_ERR_AMP_OUT}
C {lab_pin.sym} 5940 -2380 0 1 {name=p15 lab=V_SAWTOOTH}
C {lab_pin.sym} 5200 -2380 0 0 {name=p25 lab=V_ERR_AMP_OUT}
C {sky130_fd_pr/nfet_01v8.sym} 5920 -3160 0 0 {name=M45
W=32
L=0.3
nf=5 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5920 -3300 0 0 {name=M46
W=32
L=0.3
nf=5 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5740 -3480 0 0 {name=M47
W=24
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6160 -3480 0 1 {name=M48
W=24
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5780 -3640 0 1 {name=M50
W=24
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6120 -3640 0 0 {name=M51
W=24
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6120 -4020 0 0 {name=M53
W=72
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5780 -4020 0 1 {name=M54
W=72
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6120 -3880 0 0 {name=M55
W=72
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5780 -3880 0 1 {name=M56
W=72
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6220 -3640 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} 5680 -3640 0 1 {name=l46 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5920 -3550 0 0 {name=M57
W=4
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5990 -4090 0 0 {name=M58
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5990 -3780 0 0 {name=M59
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 5890 -4090 0 0 {name=p32 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 5950 -3880 0 0 {name=p33 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 5770 -3300 2 1 {name=p46 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 5770 -3160 2 1 {name=p47 sig_type=std_logic lab=Vbias4}
C {lab_pin.sym} 6140 -3780 0 1 {name=p48 lab=ERR_AMP_OUT}
C {lab_pin.sym} 5760 -3780 0 0 {name=p49 lab=ERR_AMP_MIR}
C {lab_wire.sym} 5910 -3390 0 0 {name=p50 sig_type=std_logic lab=Vp}
C {lab_wire.sym} 5900 -3640 0 0 {name=p51 sig_type=std_logic lab=Vb1}
C {devices/ngspice_get_value.sym} 5920 -3120 2 0 {name=r5 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5920 -3260 2 0 {name=r6 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5740 -3440 2 0 {name=r15 node=v(@m.xm36.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6160 -3440 2 1 {name=r16 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5920 -3520 2 0 {name=r17 node=v(@m.xm44.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5780 -3610 2 1 {name=r19 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6120 -3610 2 0 {name=r20 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5990 -3740 2 0 {name=r21 node=v(@m.xm46.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5780 -3850 2 1 {name=r40 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6120 -3850 2 0 {name=r41 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5780 -3980 2 1 {name=r42 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6120 -3980 2 0 {name=r43 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5990 -4060 2 0 {name=r44 node=v(@m.xm45.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6120 -3580 2 0 {name=r45 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 6150 -3580 2 1 {name=r46 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {devices/ngspice_get_value.sym} 6000 -3260 2 1 {name=r47 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 6000 -3220 2 1 {name=r48 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {devices/ngspice_get_value.sym} 6000 -3130 2 1 {name=r49 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 6000 -3090 2 1 {name=r50 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {lab_wire.sym} 5940 -3220 0 1 {name=p52 sig_type=std_logic lab=V_tail_btw}
C {lab_wire.sym} 5760 -3530 0 0 {name=p53 sig_type=std_logic lab=Vd1}
C {lab_wire.sym} 6140 -3540 0 1 {name=p54 sig_type=std_logic lab=Vd2}
C {lab_wire.sym} 5760 -4120 0 1 {name=p60 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 6010 -4190 0 1 {name=p61 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 6140 -4120 0 1 {name=p62 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 5940 -3060 2 1 {name=p55 sig_type=std_logic lab=GNDA}
C {lab_pin.sym} 5590 -3480 0 0 {name=p26 lab=VIN_P}
C {lab_pin.sym} 6310 -3480 0 1 {name=p27 lab=VIN_M}
C {devices/gnd.sym} 8380 -3250 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 8540 -3370 0 0 {name=M37
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8200 -3370 0 1 {name=M44
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8160 -3750 0 0 {name=M60
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8580 -3750 0 1 {name=M61
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8160 -3610 0 0 {name=M62
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8580 -3610 0 1 {name=M63
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8070 -3750 0 0 {name=p37 lab=V_CTRL_VTC}
C {lab_pin.sym} 8180 -3510 0 0 {name=p38 lab=SAWTOOTH_AMP_OUT}
C {lab_pin.sym} 8560 -3510 0 1 {name=p39 lab=SAWTOOTH_AMP_MIR}
C {devices/ngspice_get_value.sym} 8540 -3340 2 0 {name=r51 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8200 -3340 2 1 {name=r52 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8540 -3580 2 0 {name=r53 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8200 -3580 2 1 {name=r54 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8540 -3710 2 0 {name=r55 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8200 -3710 2 1 {name=r56 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 7910 -3370 0 1 {name=M64
W=20
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7610 -3370 0 1 {name=M65
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7610 -3610 0 1 {name=M66
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7570 -3580 2 0 {name=r57 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7900 -3340 2 1 {name=r58 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7600 -3340 2 1 {name=r59 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 7590 -3730 0 1 {name=l31 lab=VDD}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8870 -3500 0 1 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=45 spiceprefix=X}
C {devices/gnd.sym} 8870 -3380 0 1 {name=l35 lab=GND}
C {devices/ngspice_get_value.sym} 9120 -3470 2 1 {name=r60 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7430 -3440 2 1 {name=p40 sig_type=std_logic lab=S_RST}
C {sky130_fd_pr/pfet_01v8.sym} 9040 -3760 0 1 {name=M67
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 9030 -3730 2 1 {name=r61 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 9200 -3760 0 1 {name=p41 sig_type=std_logic lab=Vbias1}
C {sky130_fd_pr/pfet_01v8.sym} 8390 -3960 0 1 {name=M68
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 8380 -3930 2 1 {name=r62 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8550 -3960 0 1 {name=p42 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 8690 -3750 0 1 {name=p43 sig_type=std_logic lab=V_SAWTOOTH}
C {lab_wire.sym} 7890 -3560 0 1 {name=p56 sig_type=std_logic lab=SAWTOOTH_PULL_DOWN}
C {devices/vdd.sym} 8370 -4080 0 1 {name=l37 lab=VDD}
C {lab_wire.sym} 8450 -3850 0 1 {name=p57 sig_type=std_logic lab=SAWTOOTH_Vp}
C {devices/vdd.sym} 9020 -4030 0 1 {name=l38 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 9040 -3910 0 1 {name=M72
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7910 -3960 0 1 {name=M73
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7900 -3930 2 1 {name=r63 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8020 -3960 0 1 {name=p58 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 7890 -4080 0 1 {name=l39 lab=VDD}
C {ammeter.sym} 8870 -3600 0 1 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 9130 -3500 0 1 {name=M74
W=4.0
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9020 -3500 0 1 {name=l40 lab=GND}
C {lab_wire.sym} 9110 -3560 0 1 {name=p59 sig_type=std_logic lab=V_SAWTOOTH}
C {lab_wire.sym} 9200 -3500 0 1 {name=p63 sig_type=std_logic lab=S_RST}
C {lab_pin.sym} 8180 -3670 0 0 {name=p64 lab=SAWTOOTH_VD2}
C {lab_pin.sym} 8560 -3670 0 1 {name=p65 lab=SAWTOOTH_VD1}
