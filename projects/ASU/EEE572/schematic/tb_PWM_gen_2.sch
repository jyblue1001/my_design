v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 6430 -1350 7090 -900 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.061











color="7 18"
node="clk_swcap


q"}
B 2 5620 -1350 6280 -900 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00013












color=6
node=s_rst}
B 2 6430 -830 7090 -380 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=6
























y1=1.5












color=7
node=v_ctrl_vtc}
B 2 5000 -2130 5260 -1940 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00012












color=6
node=s_rst}
B 2 5000 -1920 5260 -1730 {flags=graph

y2=0.0008
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.00075












color="6 7"
node="i(@m.xm37.msky130_fd_pr__nfet_01v8[id])
i(vmeas)"}
B 2 6030 -1820 6290 -1630 {flags=graph

y2=1.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color=6
node=i(@m.xm34.msky130_fd_pr__nfet_01v8[id])}
B 2 5670 -1820 5930 -1630 {flags=graph

y2=3e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=3e-09












color="6 7"
node="i(@m.xm38.msky130_fd_pr__nfet_01v8[id])
i(@m.xm39.msky130_fd_pr__nfet_01v8[id])"}
B 2 6330 -1820 6590 -1630 {flags=graph

y2=0.00017
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.5e-12












color="6 7 11"
node="i(@m.xm34.msky130_fd_pr__nfet_01v8[id])
i(@m.xm36.msky130_fd_pr__pfet_01v8[id])
i(@m.xm35.msky130_fd_pr__nfet_01v8[id])"}
B 2 6030 -1610 6290 -1420 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.79













color=7
node=pull_down}
B 2 5360 -1820 5620 -1630 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.012













color="7 6"
node="vin_p
v_ctrl_vtc"}
B 2 5670 -1610 5930 -1420 {flags=graph

y2=0.57
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00034














color=7
node=amp_out}
B 2 7930 -2160 8190 -1970 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0













color="7 6"
node="v_sawtooth
v_err_amp_out"}
B 2 8670 -2160 8930 -1970 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.052














color=6
node=v_q_b}
B 2 7930 -2370 8190 -2180 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.09














color=6
node=v_err_amp_out}
B 2 8670 -1940 8930 -1750 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.018














color=7
node=v_final_pwm}
B 2 8220 -2160 8480 -1970 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0018















color=7
node=clk_out}
B 2 1500 -3040 1730 -2880 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.2e-13









color=7
node=v_ref}
T {3.1uA} 7810 -5450 0 1 1 1 {}
T {100nA} 7340 -5440 0 1 1 1 {}
T {24/(0.3 * 2)} 7800 -5570 0 1 0.5 0.5 {}
T {24/(0.3 * 8)} 7260 -5580 0 1 0.5 0.5 {}
T {r=7769} 2230 -2880 0 0 0.4 0.4 {}
T {3.1uA} 7780 -4210 0 1 1 1 {}
T {100nA} 7310 -4200 0 1 1 1 {}
T {24/(0.3 * 2)} 7770 -4330 0 1 0.5 0.5 {}
T {24/(0.3 * 8)} 7230 -4340 0 1 0.5 0.5 {}
N 7710 -4900 8010 -4900 {lab=CMP_AMP_MIR}
N 8050 -5380 8050 -5310 {lab=Vp}
N 7670 -5380 7670 -5310 {lab=Vp}
N 8050 -5250 8050 -5170 {lab=VD1}
N 7670 -5250 7670 -5170 {lab=VD2}
N 7670 -5110 7670 -4930 {lab=CMP_AMP_OUT}
N 8050 -5110 8050 -4930 {lab=CMP_AMP_MIR}
N 7670 -4800 8050 -4800 {lab=GND}
N 7870 -4800 7870 -4770 {lab=GND}
N 8090 -5280 8150 -5280 {lab=V_ERR_AMP_OUT}
N 7560 -5280 7630 -5280 {lab=V_SAWTOOTH}
N 6820 -2380 6820 -2330 {lab=V_CTRL_VTC}
N 7870 -4980 8050 -4980 {lab=CMP_AMP_MIR}
N 7870 -4980 7870 -4900 {lab=CMP_AMP_MIR}
N 8120 -4900 8120 -4800 {lab=GND}
N 8050 -4800 8120 -4800 {lab=GND}
N 8050 -4900 8120 -4900 {lab=GND}
N 7600 -4900 7600 -4800 {lab=GND}
N 7600 -4800 7670 -4800 {lab=GND}
N 7600 -4900 7670 -4900 {lab=GND}
N 8120 -5140 8120 -4900 {lab=GND}
N 7600 -5140 7600 -4900 {lab=GND}
N 7670 -5140 8050 -5140 {lab=VDD}
N 7670 -5280 8050 -5280 {lab=VDD}
N 7820 -5280 7820 -5140 {lab=VDD}
N 8050 -4870 8050 -4800 {lab=GND}
N 7670 -4870 7670 -4800 {lab=GND}
N 7340 -4900 7340 -4800 {lab=GND}
N 7340 -4800 7380 -4800 {lab=GND}
N 7340 -4900 7380 -4900 {lab=GND}
N 7380 -4870 7380 -4800 {lab=GND}
N 7040 -4900 7040 -4800 {lab=GND}
N 7040 -4800 7080 -4800 {lab=GND}
N 7040 -4900 7080 -4900 {lab=GND}
N 7080 -4870 7080 -4800 {lab=GND}
N 7550 -4980 7550 -4900 {lab=CMP_AMP_OUT}
N 7420 -4900 7550 -4900 {lab=CMP_AMP_OUT}
N 7380 -5460 7380 -4930 {lab=PULL_DOWN}
N 7170 -4980 7170 -4900 {lab=PULL_DOWN}
N 7120 -4900 7170 -4900 {lab=PULL_DOWN}
N 7080 -5110 7080 -4930 {lab=CLK_OUT}
N 7170 -5140 7170 -4980 {lab=PULL_DOWN}
N 7120 -5140 7170 -5140 {lab=PULL_DOWN}
N 7170 -5030 7380 -5030 {lab=PULL_DOWN}
N 7040 -5210 7040 -5140 {lab=VDD}
N 7040 -5140 7080 -5140 {lab=VDD}
N 7080 -5210 7080 -5170 {lab=VDD}
N 7040 -5210 7080 -5210 {lab=VDD}
N 7080 -5260 7080 -5210 {lab=VDD}
N 7670 -5380 8050 -5380 {lab=Vp}
N 7860 -5460 7860 -5380 {lab=Vp}
N 6940 -5030 7080 -5030 {lab=CLK_OUT}
N 8090 -5140 8120 -5140 {lab=GND}
N 7600 -5140 7630 -5140 {lab=GND}
N 7380 -4800 7600 -4800 {lab=GND}
N 7080 -4800 7340 -4800 {lab=GND}
N 7820 -5490 7860 -5490 {lab=VDD}
N 7900 -5490 7940 -5490 {lab=Vbias1}
N 7940 -5490 8040 -5490 {lab=Vbias1}
N 8150 -5280 8210 -5280 {lab=V_ERR_AMP_OUT}
N 7820 -5490 7820 -5280 {lab=VDD}
N 7820 -5570 7860 -5570 {lab=VDD}
N 7860 -5610 7860 -5520 {lab=VDD}
N 7820 -5570 7820 -5490 {lab=VDD}
N 7340 -5490 7380 -5490 {lab=VDD}
N 7420 -5490 7460 -5490 {lab=Vbias1}
N 7460 -5490 7510 -5490 {lab=Vbias1}
N 7340 -5570 7380 -5570 {lab=VDD}
N 7340 -5570 7340 -5490 {lab=VDD}
N 7380 -5610 7380 -5520 {lab=VDD}
N 7550 -4980 7670 -4980 {lab=CMP_AMP_OUT}
N 7510 -520 7510 -500 {lab=VDD}
N 7510 -440 7510 -420 {lab=GND}
N 6920 -5030 6940 -5030 {lab=CLK_OUT}
N 7000 -2380 7000 -2330 {lab=V_ERR_AMP_OUT}
N 1180 -3430 1180 -2810 {lab=V_REF_MIR}
N 2130 -3430 2130 -2810 {lab=V_REF}
N 1180 -3560 1180 -3490 {lab=VDD}
N 2130 -3560 2130 -3490 {lab=VDD}
N 1180 -2750 1180 -2680 {lab=GND}
N 2130 -2750 2130 -2680 {lab=V_RES}
N 1180 -2870 1290 -2870 {lab=V_REF_MIR}
N 1290 -2870 1290 -2780 {lab=V_REF_MIR}
N 2130 -3460 2170 -3460 {lab=VDD}
N 2170 -3520 2170 -3460 {lab=VDD}
N 2130 -3520 2170 -3520 {lab=VDD}
N 1140 -3460 1180 -3460 {lab=VDD}
N 1140 -3520 1140 -3460 {lab=VDD}
N 1140 -3520 1180 -3520 {lab=VDD}
N 1140 -2720 1180 -2720 {lab=GND}
N 1140 -2780 1140 -2720 {lab=GND}
N 1140 -2780 1180 -2780 {lab=GND}
N 2130 -2780 2260 -2780 {lab=GND}
N 730 -3120 730 -2950 {lab=START_UP}
N 730 -3250 730 -3180 {lab=VDD}
N 690 -3150 730 -3150 {lab=VDD}
N 690 -3210 690 -3150 {lab=VDD}
N 690 -3210 730 -3210 {lab=VDD}
N 690 -2920 690 -2860 {lab=GND}
N 690 -2920 730 -2920 {lab=GND}
N 920 -3070 990 -3070 {lab=GND}
N 730 -3070 880 -3070 {lab=START_UP}
N 770 -3150 800 -3150 {lab=START_UP}
N 800 -3150 800 -3070 {lab=START_UP}
N 920 -3110 920 -3100 {lab=Vbiasp}
N 920 -3040 920 -3030 {lab=V_REF_MIR}
N 920 -3030 1180 -3030 {lab=V_REF_MIR}
N 2070 -2650 2110 -2650 {lab=GND}
N 2130 -2620 2130 -2540 {lab=GND}
N 770 -2920 1180 -2920 {lab=V_REF_MIR}
N 730 -2890 730 -2810 {lab=GND}
N 730 -2810 730 -2690 {lab=GND}
N 690 -2860 730 -2860 {lab=GND}
N 1430 -3610 1430 -2630 {lab=Vbiasp_MIR}
N 1810 -3610 1810 -2630 {lab=Vbiasp}
N 1470 -3640 1770 -3640 {lab=Vbiasp_MIR}
N 1430 -3740 1430 -3670 {lab=VDD}
N 1810 -3740 1810 -3670 {lab=VDD}
N 1430 -2570 1430 -2500 {lab=GND}
N 1810 -2570 1810 -2500 {lab=GND}
N 1810 -3640 1850 -3640 {lab=VDD}
N 1850 -3700 1850 -3640 {lab=VDD}
N 1810 -3700 1850 -3700 {lab=VDD}
N 1390 -3640 1430 -3640 {lab=VDD}
N 1390 -3700 1390 -3640 {lab=VDD}
N 1390 -3700 1430 -3700 {lab=VDD}
N 1390 -2540 1430 -2540 {lab=GND}
N 1390 -2600 1390 -2540 {lab=GND}
N 1390 -2600 1430 -2600 {lab=GND}
N 1810 -2540 1850 -2540 {lab=GND}
N 1850 -2600 1850 -2540 {lab=GND}
N 1810 -2600 1850 -2600 {lab=GND}
N 1610 -3640 1610 -3530 {lab=Vbiasp_MIR}
N 1430 -3530 1610 -3530 {lab=Vbiasp_MIR}
N 1220 -2780 1290 -2780 {lab=V_REF_MIR}
N 1290 -2780 1640 -2780 {lab=V_REF_MIR}
N 1640 -2780 1770 -2600 {lab=V_REF_MIR}
N 1470 -2600 1710 -2780 {lab=V_REF}
N 1710 -2780 2090 -2780 {lab=V_REF}
N 2010 -2870 2010 -2780 {lab=V_REF}
N 2010 -2870 2130 -2870 {lab=V_REF}
N 1220 -3460 1810 -3460 {lab=Vbiasp}
N 1810 -3460 2090 -3460 {lab=Vbiasp}
N 920 -3110 1810 -3110 {lab=Vbiasp}
N 2530 -2620 2530 -2550 {lab=GND}
N 2490 -2590 2530 -2590 {lab=GND}
N 2490 -2650 2490 -2590 {lab=GND}
N 2490 -2650 2530 -2650 {lab=GND}
N 2530 -3280 2530 -3210 {lab=VDD}
N 2530 -3180 2570 -3180 {lab=VDD}
N 2570 -3240 2570 -3180 {lab=VDD}
N 2530 -3240 2570 -3240 {lab=VDD}
N 2530 -3150 2530 -2680 {lab=Vbias3}
N 4300 -3280 4600 -3280 {lab=Vbias1}
N 4260 -3380 4260 -3310 {lab=VDD}
N 4640 -3380 4640 -3310 {lab=VDD}
N 4640 -3280 4680 -3280 {lab=VDD}
N 4680 -3340 4680 -3280 {lab=VDD}
N 4640 -3340 4680 -3340 {lab=VDD}
N 4220 -3280 4260 -3280 {lab=VDD}
N 4220 -3340 4220 -3280 {lab=VDD}
N 4220 -3340 4260 -3340 {lab=VDD}
N 4440 -3280 4440 -3170 {lab=Vbias1}
N 4260 -2830 4440 -2830 {lab=Vbias1}
N 4300 -3010 4600 -3010 {lab=Vbias2}
N 4260 -3110 4260 -3040 {lab=Vhigh}
N 4640 -3110 4640 -3040 {lab=#net1}
N 4640 -3010 4680 -3010 {lab=VDD}
N 4680 -3070 4680 -3010 {lab=VDD}
N 4220 -3010 4260 -3010 {lab=VDD}
N 4220 -3070 4220 -3010 {lab=VDD}
N 4260 -3250 4260 -3110 {lab=Vhigh}
N 4640 -3250 4640 -3110 {lab=#net1}
N 4440 -3170 4440 -2830 {lab=Vbias1}
N 4260 -2980 4260 -2760 {lab=Vbias1}
N 4640 -2980 4640 -2760 {lab=Vncas}
N 4160 -2920 4360 -2920 {lab=Vbias2}
N 4360 -3010 4360 -2920 {lab=Vbias2}
N 4260 -2330 4260 -2260 {lab=GND}
N 4260 -2300 4300 -2300 {lab=GND}
N 4300 -2360 4300 -2300 {lab=GND}
N 4260 -2360 4300 -2360 {lab=GND}
N 4260 -2450 4260 -2390 {lab=#net2}
N 4070 -2360 4220 -2360 {lab=Vbias4}
N 4640 -2550 4640 -2480 {lab=#net3}
N 4600 -2580 4600 -2520 {lab=GND}
N 4600 -2580 4640 -2580 {lab=GND}
N 4640 -2760 4640 -2610 {lab=Vncas}
N 4640 -2800 4950 -2800 {lab=Vncas}
N 4680 -2580 4770 -2580 {lab=Vncas}
N 4640 -2330 4640 -2260 {lab=#net4}
N 4680 -2360 4680 -2300 {lab=GND}
N 4640 -2360 4680 -2360 {lab=GND}
N 4640 -2480 4640 -2390 {lab=#net3}
N 4640 -2200 4640 -2130 {lab=GND}
N 4640 -2170 4680 -2170 {lab=GND}
N 4680 -2230 4680 -2170 {lab=GND}
N 4640 -2230 4680 -2230 {lab=GND}
N 4510 -2230 4600 -2230 {lab=#net3}
N 4600 -2520 4680 -2520 {lab=GND}
N 4680 -2520 4680 -2360 {lab=GND}
N 4680 -2300 4680 -2230 {lab=GND}
N 4510 -2440 4510 -2230 {lab=#net3}
N 4510 -2440 4640 -2440 {lab=#net3}
N 4220 -3280 4220 -3070 {lab=VDD}
N 4680 -3280 4680 -3070 {lab=VDD}
N 2870 -3280 2870 -3210 {lab=VDD}
N 2870 -3180 2910 -3180 {lab=VDD}
N 2910 -3240 2910 -3180 {lab=VDD}
N 2870 -3240 2910 -3240 {lab=VDD}
N 2870 -3010 2870 -2940 {lab=Vbias4}
N 2870 -3150 2870 -3010 {lab=Vbias4}
N 2870 -2880 2870 -2660 {lab=Vbias4}
N 2830 -2560 2830 -2500 {lab=GND}
N 2870 -2660 2870 -2590 {lab=Vbias4}
N 2830 -2560 2870 -2560 {lab=GND}
N 2870 -2530 2870 -2460 {lab=Vlow}
N 4440 -3210 4950 -3210 {lab=Vbias1}
N 2720 -3180 2720 -3110 {lab=Vbiasp}
N 2720 -3180 2830 -3180 {lab=Vbiasp}
N 2830 -2360 2830 -2300 {lab=GND}
N 2870 -2460 2870 -2390 {lab=Vlow}
N 2830 -2360 2870 -2360 {lab=GND}
N 2870 -2330 2870 -2260 {lab=GND}
N 2830 -2300 2870 -2300 {lab=GND}
N 2910 -2360 2990 -2360 {lab=Vbias4}
N 2990 -2720 2990 -2360 {lab=Vbias4}
N 2870 -2720 2990 -2720 {lab=Vbias4}
N 4360 -2920 4950 -2920 {lab=Vbias2}
N 4770 -2800 4770 -2580 {lab=Vncas}
N 2830 -2500 2830 -2360 {lab=GND}
N 3320 -3280 3320 -3210 {lab=VDD}
N 3320 -3180 3360 -3180 {lab=VDD}
N 3360 -3240 3360 -3180 {lab=VDD}
N 3320 -3240 3360 -3240 {lab=VDD}
N 3320 -3010 3320 -2940 {lab=Vds2}
N 3320 -2910 3360 -2910 {lab=VDD}
N 3360 -2970 3360 -2910 {lab=VDD}
N 3320 -3150 3320 -3010 {lab=Vds2}
N 3360 -2560 3360 -2500 {lab=GND}
N 3320 -2660 3320 -2590 {lab=Vpcas}
N 3360 -3180 3360 -2970 {lab=VDD}
N 3320 -2560 3360 -2560 {lab=GND}
N 3320 -2530 3320 -2460 {lab=Vds3}
N 3210 -3180 3210 -3110 {lab=Vgs2}
N 3210 -3180 3280 -3180 {lab=Vgs2}
N 3360 -2360 3360 -2300 {lab=GND}
N 3320 -2460 3320 -2390 {lab=Vds3}
N 3320 -2360 3360 -2360 {lab=GND}
N 3320 -2330 3320 -2260 {lab=GND}
N 3320 -2300 3360 -2300 {lab=GND}
N 3200 -2360 3280 -2360 {lab=Vbias4}
N 3110 -2910 3280 -2910 {lab=Vbias2}
N 3360 -2500 3360 -2360 {lab=GND}
N 2990 -2360 3200 -2360 {lab=Vbias4}
N 2910 -2560 3280 -2560 {lab=Vbias3}
N 3110 -2650 3110 -2560 {lab=Vbias3}
N 3320 -2780 3360 -2780 {lab=VDD}
N 3360 -2840 3360 -2780 {lab=VDD}
N 3210 -2780 3210 -2690 {lab=Vpcas}
N 3210 -2780 3280 -2780 {lab=Vpcas}
N 3360 -2910 3360 -2840 {lab=VDD}
N 3320 -2880 3320 -2810 {lab=Vgs2}
N 3210 -3110 3210 -2850 {lab=Vgs2}
N 3210 -2850 3320 -2850 {lab=Vgs2}
N 3320 -2750 3320 -2660 {lab=Vpcas}
N 3210 -2690 3320 -2690 {lab=Vpcas}
N 3320 -2690 3580 -2690 {lab=Vpcas}
N 4410 -2360 4600 -2360 {lab=Vbias3}
N 2390 -3110 2420 -3110 {lab=Vbiasp}
N 3110 -2650 3580 -2650 {lab=Vbias3}
N 2870 -2490 3580 -2490 {lab=Vlow}
N 2990 -2440 3580 -2440 {lab=Vbias4}
N 4260 -3130 4950 -3130 {lab=Vhigh}
N 1980 -3460 1980 -3370 {lab=Vbiasp}
N 2410 -3180 2490 -3180 {lab=Vbiasp}
N 1980 -3180 2410 -3180 {lab=Vbiasp}
N 1980 -3370 1980 -3180 {lab=Vbiasp}
N 2870 -2940 2870 -2880 {lab=Vbias4}
N 2570 -2650 2780 -2650 {lab=Vbias3}
N 2640 -2760 2640 -2650 {lab=Vbias3}
N 2530 -2760 2640 -2760 {lab=Vbias3}
N 2420 -3110 2720 -3110 {lab=Vbiasp}
N 2390 -3180 2390 -3110 {lab=Vbiasp}
N 2780 -2650 3110 -2650 {lab=Vbias3}
N 4260 -2540 4260 -2450 {lab=#net2}
N 4260 -2570 4300 -2570 {lab=GND}
N 4260 -2760 4260 -2600 {lab=Vbias1}
N 4300 -2570 4300 -2360 {lab=GND}
N 4070 -2570 4220 -2570 {lab=Vbias3}
N 3870 -2920 3910 -2920 {lab=VDD}
N 3910 -2890 3910 -2760 {lab=Vbias2}
N 3910 -2330 3910 -2260 {lab=GND}
N 3910 -2300 3950 -2300 {lab=GND}
N 3950 -2360 3950 -2300 {lab=GND}
N 3910 -2360 3950 -2360 {lab=GND}
N 3910 -2450 3910 -2390 {lab=#net5}
N 3720 -2360 3870 -2360 {lab=Vbias4}
N 3910 -2540 3910 -2450 {lab=#net5}
N 3910 -2570 3950 -2570 {lab=GND}
N 3910 -2760 3910 -2600 {lab=Vbias2}
N 3950 -2570 3950 -2360 {lab=GND}
N 3720 -2570 3870 -2570 {lab=Vbias3}
N 3910 -3020 3910 -2950 {lab=VDD}
N 3870 -2980 3870 -2920 {lab=VDD}
N 3870 -2980 3910 -2980 {lab=VDD}
N 3950 -2920 4160 -2920 {lab=Vbias2}
N 4000 -2920 4000 -2830 {lab=Vbias2}
N 3910 -2830 4000 -2830 {lab=Vbias2}
N 3580 -2650 3720 -2650 {lab=Vbias3}
N 3720 -2650 3720 -2570 {lab=Vbias3}
N 3580 -2440 3720 -2440 {lab=Vbias4}
N 3720 -2440 3720 -2360 {lab=Vbias4}
N 4070 -2650 4070 -2570 {lab=Vbias3}
N 4070 -2440 4070 -2360 {lab=Vbias4}
N 3720 -2440 4070 -2440 {lab=Vbias4}
N 3720 -2650 4070 -2650 {lab=Vbias3}
N 4070 -2650 4410 -2650 {lab=Vbias3}
N 4410 -2650 4410 -2360 {lab=Vbias3}
N 2300 -3410 2300 -3320 {lab=VDD}
N 2300 -3260 2300 -3180 {lab=Vbiasp}
N 7000 -2200 7000 -2150 {lab=V_SAWTOOTH}
N 9520 -4760 9520 -4690 {lab=GND}
N 9520 -4730 9560 -4730 {lab=GND}
N 9560 -4790 9560 -4730 {lab=GND}
N 9520 -4790 9560 -4790 {lab=GND}
N 9560 -4930 9560 -4870 {lab=GND}
N 9520 -4930 9560 -4930 {lab=GND}
N 9520 -4900 9520 -4820 {lab=V_tail_btw}
N 9560 -4870 9560 -4790 {lab=GND}
N 9380 -5270 9680 -5270 {lab=Vb1}
N 9380 -5650 9680 -5650 {lab=AMP_MIR}
N 9340 -5750 9340 -5680 {lab=VDD}
N 9720 -5750 9720 -5680 {lab=VDD}
N 9720 -5650 9760 -5650 {lab=VDD}
N 9760 -5710 9760 -5650 {lab=VDD}
N 9720 -5710 9760 -5710 {lab=VDD}
N 9300 -5650 9340 -5650 {lab=VDD}
N 9300 -5710 9300 -5650 {lab=VDD}
N 9300 -5710 9340 -5710 {lab=VDD}
N 9380 -5510 9680 -5510 {lab=Vbias2}
N 9720 -5510 9760 -5510 {lab=VDD}
N 9300 -5510 9340 -5510 {lab=VDD}
N 9300 -5650 9300 -5510 {lab=VDD}
N 9760 -5650 9760 -5510 {lab=VDD}
N 9340 -5240 9340 -5140 {lab=Vd1}
N 9720 -5240 9720 -5140 {lab=Vd2}
N 9340 -5620 9340 -5540 {lab=#net6}
N 9720 -5620 9720 -5540 {lab=#net7}
N 9720 -5480 9720 -5300 {lab=AMP_OUT}
N 9340 -5480 9340 -5300 {lab=AMP_MIR}
N 9260 -5270 9340 -5270 {lab=GND}
N 9720 -5270 9800 -5270 {lab=GND}
N 9340 -5080 9340 -5020 {lab=Vp}
N 9340 -5020 9720 -5020 {lab=Vp}
N 9720 -5080 9720 -5020 {lab=Vp}
N 9520 -5020 9520 -4960 {lab=Vp}
N 9560 -5110 9560 -4930 {lab=GND}
N 9560 -5110 9720 -5110 {lab=GND}
N 9340 -5110 9560 -5110 {lab=GND}
N 9520 -5150 9520 -5020 {lab=Vp}
N 9520 -5180 9560 -5180 {lab=GND}
N 9560 -5180 9560 -5110 {lab=GND}
N 9520 -5270 9520 -5210 {lab=Vb1}
N 9450 -5180 9480 -5180 {lab=Vb1}
N 9450 -5230 9450 -5180 {lab=Vb1}
N 9450 -5230 9520 -5230 {lab=Vb1}
N 9340 -5330 9420 -5330 {lab=AMP_MIR}
N 9420 -5650 9420 -5330 {lab=AMP_MIR}
N 9590 -5720 9630 -5720 {lab=VDD}
N 9590 -5410 9630 -5410 {lab=VDD}
N 9590 -5690 9590 -5440 {lab=#net8}
N 9630 -5720 9630 -5410 {lab=VDD}
N 9590 -5380 9590 -5270 {lab=Vb1}
N 9590 -5820 9590 -5750 {lab=VDD}
N 9630 -5780 9630 -5720 {lab=VDD}
N 9590 -5780 9630 -5780 {lab=VDD}
N 9510 -5410 9550 -5410 {lab=Vbias2}
N 9510 -5510 9510 -5410 {lab=Vbias2}
N 9470 -5720 9550 -5720 {lab=Vbias1}
N 9350 -4930 9480 -4930 {lab=Vbias3}
N 9350 -4790 9480 -4790 {lab=Vbias4}
N 7680 -3660 7980 -3660 {lab=CMP_AMP_MIR}
N 8020 -4140 8020 -4070 {lab=Vp}
N 7640 -4140 7640 -4070 {lab=Vp}
N 8020 -4010 8020 -3930 {lab=VD1}
N 7640 -4010 7640 -3930 {lab=VD2}
N 7640 -3870 7640 -3690 {lab=CMP_AMP_OUT}
N 8020 -3870 8020 -3690 {lab=CMP_AMP_MIR}
N 7640 -3560 8020 -3560 {lab=GND}
N 7840 -3560 7840 -3530 {lab=GND}
N 8060 -4040 8120 -4040 {lab=V_ERR_AMP_OUT}
N 7530 -4040 7600 -4040 {lab=V_SAWTOOTH}
N 7840 -3740 8020 -3740 {lab=CMP_AMP_MIR}
N 7840 -3740 7840 -3660 {lab=CMP_AMP_MIR}
N 8090 -3660 8090 -3560 {lab=GND}
N 8020 -3560 8090 -3560 {lab=GND}
N 8020 -3660 8090 -3660 {lab=GND}
N 7570 -3660 7570 -3560 {lab=GND}
N 7570 -3560 7640 -3560 {lab=GND}
N 7570 -3660 7640 -3660 {lab=GND}
N 8090 -3900 8090 -3660 {lab=GND}
N 7570 -3900 7570 -3660 {lab=GND}
N 7640 -3900 8020 -3900 {lab=VDD}
N 7640 -4040 8020 -4040 {lab=VDD}
N 7790 -4040 7790 -3900 {lab=VDD}
N 8020 -3630 8020 -3560 {lab=GND}
N 7640 -3630 7640 -3560 {lab=GND}
N 7310 -3660 7310 -3560 {lab=GND}
N 7310 -3560 7350 -3560 {lab=GND}
N 7310 -3660 7350 -3660 {lab=GND}
N 7350 -3630 7350 -3560 {lab=GND}
N 7010 -3660 7010 -3560 {lab=GND}
N 7010 -3560 7050 -3560 {lab=GND}
N 7010 -3660 7050 -3660 {lab=GND}
N 7050 -3630 7050 -3560 {lab=GND}
N 7520 -3740 7520 -3660 {lab=CMP_AMP_OUT}
N 7390 -3660 7520 -3660 {lab=CMP_AMP_OUT}
N 7350 -4220 7350 -3690 {lab=PULL_DOWN}
N 7140 -3740 7140 -3660 {lab=PULL_DOWN}
N 7090 -3660 7140 -3660 {lab=PULL_DOWN}
N 7050 -3870 7050 -3690 {lab=CLK_OUT}
N 7140 -3900 7140 -3740 {lab=PULL_DOWN}
N 7090 -3900 7140 -3900 {lab=PULL_DOWN}
N 7140 -3790 7350 -3790 {lab=PULL_DOWN}
N 7010 -3970 7010 -3900 {lab=VDD}
N 7010 -3900 7050 -3900 {lab=VDD}
N 7050 -3970 7050 -3930 {lab=VDD}
N 7010 -3970 7050 -3970 {lab=VDD}
N 7050 -4020 7050 -3970 {lab=VDD}
N 7640 -4140 8020 -4140 {lab=Vp}
N 7830 -4220 7830 -4140 {lab=Vp}
N 6910 -3790 7050 -3790 {lab=CLK_OUT}
N 8060 -3900 8090 -3900 {lab=GND}
N 7570 -3900 7600 -3900 {lab=GND}
N 7350 -3560 7570 -3560 {lab=GND}
N 7050 -3560 7310 -3560 {lab=GND}
N 7790 -4250 7830 -4250 {lab=VDD}
N 7870 -4250 7910 -4250 {lab=Vbias1}
N 7910 -4250 8010 -4250 {lab=Vbias1}
N 8120 -4040 8180 -4040 {lab=V_ERR_AMP_OUT}
N 7790 -4250 7790 -4040 {lab=VDD}
N 7790 -4330 7830 -4330 {lab=VDD}
N 7830 -4370 7830 -4280 {lab=VDD}
N 7790 -4330 7790 -4250 {lab=VDD}
N 7310 -4250 7350 -4250 {lab=VDD}
N 7390 -4250 7430 -4250 {lab=Vbias1}
N 7430 -4250 7480 -4250 {lab=Vbias1}
N 7310 -4330 7350 -4330 {lab=VDD}
N 7310 -4330 7310 -4250 {lab=VDD}
N 7350 -4370 7350 -4280 {lab=VDD}
N 7520 -3740 7640 -3740 {lab=CMP_AMP_OUT}
N 6890 -3790 6910 -3790 {lab=CLK_OUT}
C {devices/vsource.sym} 7510 -470 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 7510 -420 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 7510 -520 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 7290 -520 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 7790 -1730 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

* .include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.save
+v(s_rst)
+v(clk_swcap)
+v(clk_swcap_d)
+v(v_ctrl_vtc)
+v(vbias1)
+v(vbias2)
+v(vin_p)
+v(v_p)
+v(vd1)
+v(vd2)
+v(amp_mir)
+v(amp_out)
+v(pull_down)
+v(sawtooth_v_p)
+v(sawtooth_vd1)
+v(sawtooth_vd2)
+v(sawtooth_amp_mir)
+v(sawtooth_amp_out)
+v(sawtooth_pull_down)
+v(v_sawtooth)
+v(err_amp_mir)
+v(err_amp_out)
+v(clk_out)
+v(v_sawtooth)
+v(v_err_amp_out)


.control
  * save all
  * dc V1 0.0 2.0 0.005
  tran 0.05ns 2us
  remzerovec
  write tb_PWM_gen_2.raw
  set appendwrite

.endc


"
}
C {devices/gnd.sym} 7870 -4780 0 1 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 8030 -4900 0 0 {name=M38
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7690 -4900 0 1 {name=M39
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7650 -5280 0 0 {name=M40
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8070 -5280 0 1 {name=M41
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7650 -5140 0 0 {name=M42
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8070 -5140 0 1 {name=M43
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 6820 -2300 0 0 {name=V2 value=1.4 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 6820 -2270 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7670 -5040 0 0 {name=p28 lab=CMP_AMP_OUT}
C {lab_pin.sym} 8050 -5040 0 1 {name=p29 lab=CMP_AMP_MIR}
C {devices/ngspice_get_value.sym} 8030 -4870 2 0 {name=r7 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7690 -4870 2 1 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8030 -5110 2 0 {name=r11 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7690 -5110 2 1 {name=r12 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8030 -5240 2 0 {name=r13 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7690 -5240 2 1 {name=r14 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 7400 -4900 0 1 {name=M34
W=20
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7100 -4900 0 1 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7100 -5140 0 1 {name=M36
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7060 -5110 2 0 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7390 -4870 2 1 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7090 -4870 2 1 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 7080 -5260 0 1 {name=l33 lab=VDD}
C {lab_wire.sym} 6920 -5030 2 1 {name=p19 sig_type=std_logic lab=CLK_OUT}
C {sky130_fd_pr/pfet_01v8.sym} 7880 -5490 0 1 {name=M49
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7870 -5460 2 1 {name=r18 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8040 -5490 0 1 {name=p30 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 6820 -2380 0 1 {name=p22 lab=V_CTRL_VTC}
C {lab_wire.sym} 7380 -5030 0 1 {name=p23 sig_type=std_logic lab=PULL_DOWN}
C {devices/vdd.sym} 7860 -5610 0 1 {name=l36 lab=VDD}
C {lab_wire.sym} 7940 -5380 0 1 {name=p24 sig_type=std_logic lab=Vp}
C {sky130_fd_pr/pfet_01v8.sym} 7400 -5490 0 1 {name=M52
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7390 -5460 2 1 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7510 -5490 0 1 {name=p31 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 7380 -5610 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 7670 -5200 0 0 {name=p34 lab=VD2}
C {lab_pin.sym} 8050 -5200 0 1 {name=p36 lab=VD1}
C {devices/vsource.sym} 7000 -2300 0 0 {name=V6 value="pwl(0 1.2 2.0us 0.2)" savecurrent=false
* 0.001 1.4 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)" }
C {devices/gnd.sym} 7000 -2270 0 0 {name=V7 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7000 -2380 0 1 {name=p45 lab=V_ERR_AMP_OUT}
C {lab_pin.sym} 7560 -5280 0 0 {name=p15 lab=V_SAWTOOTH}
C {lab_pin.sym} 8210 -5280 0 1 {name=p25 lab=V_ERR_AMP_OUT}
C {sky130_fd_pr/nfet_01v8.sym} 2110 -2780 0 0 {name=M1
W=16
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1200 -2780 0 1 {name=M2
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 -2920 0 1 {name=M5
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 900 -3070 0 0 {name=M7
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 -2540 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 2070 -2650 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 1180 -2680 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 730 -2690 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 990 -3070 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 2260 -2780 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 730 -3250 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 1180 -3560 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 2130 -3560 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 2130 -2710 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 730 -3070 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 750 -3150 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2110 -3460 0 0 {name=M3
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1200 -3460 0 1 {name=M4
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 2290 -2700 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -2600 0 0 {name=M8
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 -2600 0 1 {name=M9
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1810 -2500 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 1430 -2500 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 1430 -3740 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1810 -3740 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1790 -3640 0 0 {name=M10
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1450 -3640 0 1 {name=M11
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2130 -3050 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2550 -2650 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2550 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2530 -3280 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2510 -3180 0 0 {name=M13
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4260 -3380 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4640 -3380 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3280 0 0 {name=M14
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3280 0 1 {name=M15
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3010 0 0 {name=M16
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3010 0 1 {name=M17
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2360 0 0 {name=M18
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4260 -2260 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4660 -2580 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2360 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2230 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4640 -2130 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2870 -3280 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2850 -3180 0 0 {name=M25
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2560 0 1 {name=M27
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2360 0 1 {name=M28
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2870 -2260 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 3320 -3280 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -3180 0 0 {name=M29
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2910 0 0 {name=M30
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2560 0 0 {name=M31
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2360 0 0 {name=M32
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3320 -2260 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2780 0 0 {name=M33
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4950 -3210 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4950 -3130 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4950 -2920 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4950 -2800 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3580 -2690 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 2390 -3110 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3580 -2650 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3580 -2490 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3580 -2440 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 4410 -2360 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3320 -3060 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 3210 -3060 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 3320 -2460 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 1430 -3320 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 1290 -2870 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2570 0 0 {name=M22
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3930 -2920 0 1 {name=M23
W=12
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2360 0 0 {name=M24
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3910 -2260 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2570 0 0 {name=M26
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3910 -3020 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 3110 -2910 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 -3290 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 2300 -3410 0 1 {name=l28 lab=VDD}
C {sky130_fd_pr/res_high_po_0p35.sym} 2130 -2650 0 0 {name=R1
L=10
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/vsource.sym} 7000 -2120 0 0 {name=V3 value="pwl(0 0 0.2us 1.8 0.2us 0 0.4us 1.8 0.4us 0 0.6us 1.8 0.6us 0 0.8us 1.8 0.8us 0 1.0us 1.8 1.0us 0 1.2us 1.8 1.2us 0 1.4us 1.8 1.4us 0 1.6us 1.8 1.6us 0 1.8us 1.8 1.8us 0 2.0us 1.8)
" savecurrent=false
* 0.001 1.4 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)" }
C {devices/gnd.sym} 7000 -2090 0 0 {name=V4 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7000 -2200 0 1 {name=p26 lab=V_SAWTOOTH}
C {sky130_fd_pr/nfet_01v8.sym} 9500 -4790 0 0 {name=M37
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9520 -4690 0 0 {name=l30 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9500 -4930 0 0 {name=M44
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9320 -5110 0 0 {name=M45
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9740 -5110 0 1 {name=M46
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9360 -5270 0 1 {name=M47
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9700 -5270 0 0 {name=M48
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9340 -5750 0 0 {name=l31 lab=VDD}
C {devices/vdd.sym} 9720 -5750 0 0 {name=l32 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 9700 -5650 0 0 {name=M50
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9360 -5650 0 1 {name=M51
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9700 -5510 0 0 {name=M53
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9360 -5510 0 1 {name=M54
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9800 -5270 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 9260 -5270 0 1 {name=l37 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9500 -5180 0 0 {name=M55
W=1
L=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9570 -5720 0 0 {name=M56
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9570 -5410 0 0 {name=M57
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9590 -5820 0 0 {name=l38 lab=VDD}
C {lab_wire.sym} 9470 -5720 0 0 {name=p27 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 9530 -5510 0 0 {name=p32 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 9350 -4930 2 1 {name=p33 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 9350 -4790 2 1 {name=p35 sig_type=std_logic lab=Vbias4}
C {lab_pin.sym} 9720 -5410 0 1 {name=p37 lab=AMP_OUT}
C {lab_pin.sym} 9340 -5410 0 0 {name=p38 lab=AMP_MIR}
C {lab_wire.sym} 9490 -5020 0 0 {name=p39 sig_type=std_logic lab=Vp}
C {lab_wire.sym} 9480 -5270 0 0 {name=p40 sig_type=std_logic lab=Vb1}
C {devices/ngspice_get_value.sym} 9500 -4750 2 0 {name=r5 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9500 -4890 2 0 {name=r6 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9320 -5070 2 0 {name=r15 node=v(@m.xm36.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9750 -5070 2 1 {name=r16 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9500 -5150 2 0 {name=r17 node=v(@m.xm44.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9360 -5240 2 1 {name=r19 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9700 -5240 2 0 {name=r20 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9570 -5370 2 0 {name=r21 node=v(@m.xm46.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9360 -5480 2 1 {name=r22 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9700 -5480 2 0 {name=r23 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9360 -5610 2 1 {name=r24 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9700 -5610 2 0 {name=r25 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9570 -5690 2 0 {name=r26 node=v(@m.xm45.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9700 -5210 2 0 {name=r27 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 9730 -5210 2 1 {name=r28 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {devices/ngspice_get_value.sym} 9580 -4890 2 1 {name=r29 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 9580 -4850 2 1 {name=r30 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {devices/ngspice_get_value.sym} 9580 -4760 2 1 {name=r31 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="}
C {devices/ngspice_get_value.sym} 9580 -4720 2 1 {name=r32 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {lab_wire.sym} 9520 -4850 0 1 {name=p41 sig_type=std_logic lab=V_tail_btw}
C {lab_wire.sym} 9340 -5160 0 0 {name=p42 sig_type=std_logic lab=Vd1}
C {lab_wire.sym} 9720 -5160 0 1 {name=p43 sig_type=std_logic lab=Vd2}
C {devices/gnd.sym} 7840 -3540 0 1 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 8000 -3660 0 0 {name=M58
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7660 -3660 0 1 {name=M59
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7620 -4040 0 0 {name=M60
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8040 -4040 0 1 {name=M61
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7620 -3900 0 0 {name=M62
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8040 -3900 0 1 {name=M63
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7640 -3800 0 0 {name=p44 lab=CMP_AMP_OUT}
C {lab_pin.sym} 8020 -3800 0 1 {name=p46 lab=CMP_AMP_MIR}
C {devices/ngspice_get_value.sym} 8000 -3630 2 0 {name=r33 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7660 -3630 2 1 {name=r34 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8000 -3870 2 0 {name=r35 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7660 -3870 2 1 {name=r36 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8000 -4000 2 0 {name=r37 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7660 -4000 2 1 {name=r38 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 7370 -3660 0 1 {name=M64
W=20
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7070 -3660 0 1 {name=M65
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7070 -3900 0 1 {name=M66
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7030 -3870 2 0 {name=r39 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7360 -3630 2 1 {name=r40 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7060 -3630 2 1 {name=r41 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 7050 -4020 0 1 {name=l40 lab=VDD}
C {lab_wire.sym} 6890 -3790 2 1 {name=p47 sig_type=std_logic lab=CLK_OUT}
C {sky130_fd_pr/pfet_01v8.sym} 7850 -4250 0 1 {name=M67
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7840 -4220 2 1 {name=r42 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8010 -4250 0 1 {name=p48 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 7350 -3790 0 1 {name=p49 sig_type=std_logic lab=PULL_DOWN}
C {devices/vdd.sym} 7830 -4370 0 1 {name=l41 lab=VDD}
C {lab_wire.sym} 7910 -4140 0 1 {name=p50 sig_type=std_logic lab=Vp}
C {sky130_fd_pr/pfet_01v8.sym} 7370 -4250 0 1 {name=M68
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7360 -4220 2 1 {name=r43 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7480 -4250 0 1 {name=p51 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 7350 -4370 0 1 {name=l42 lab=VDD}
C {lab_pin.sym} 7640 -3960 0 0 {name=p52 lab=VD2}
C {lab_pin.sym} 8020 -3960 0 1 {name=p53 lab=VD1}
C {lab_pin.sym} 7530 -4040 0 0 {name=p54 lab=V_SAWTOOTH}
C {lab_pin.sym} 8180 -4040 0 1 {name=p55 lab=V_ERR_AMP_OUT}
