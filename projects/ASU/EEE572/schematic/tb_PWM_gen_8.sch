v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 8120 -2400 8380 -2210 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00082














color="6 7"
node="st_v_ref
v_sawtooth"}
B 2 8120 -2610 8380 -2420 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.038















color=7
node=s_rst}
B 2 1500 -3040 1730 -2880 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.2e-13









color=7
node=v_ref}
B 2 6650 -2630 6910 -2440 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.87
















color="6 7"
node="st_pull_down
st_pull_down2"}
B 2 6960 -2630 7220 -2440 {flags=graph

y2=0.71
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0005

















color="7 6"
node="st_amp_out
st_amp_mir"}
B 2 6220 -2630 6480 -2440 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=6.6e-07

















color=7
node=s_rst}
B 2 8400 -2610 8660 -2420 {flags=graph

y2=0.00081
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.6e-13
















color=7
node=i(@m.xm69.msky130_fd_pr__nfet_01v8[id])}
B 2 6650 -2410 6910 -2220 {flags=graph

y2=3.2e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-1.4e-06


















color=7
node=i(vmeas1)}
B 2 6960 -2410 7220 -2220 {flags=graph

y2=4.9e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=9.8e-14

















color=7
node=i(@m.xm64.msky130_fd_pr__nfet_01v8[id])}
B 2 7540 -2410 7800 -2220 {flags=graph

y2=4.9e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=9.8e-14


















color=7
node=i(@m.xm67.msky130_fd_pr__pfet_01v8[id])}
B 2 7270 -2630 7530 -2440 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=2e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00082














color="6 7"
node="st_v_ref
v_sawtooth"}
T {r=7769} 2230 -2880 0 0 0.4 0.4 {}
N 5690 -2340 5690 -2290 {lab=ST_V_REF}
N 5590 -2320 5590 -2300 {lab=VDD}
N 5590 -2240 5590 -2220 {lab=GND}
N 1180 -3430 1180 -2810 {lab=V_REF_MIR}
N 2130 -3430 2130 -2810 {lab=V_REF}
N 1180 -3560 1180 -3490 {lab=VDD}
N 2130 -3560 2130 -3490 {lab=VDD}
N 1180 -2750 1180 -2680 {lab=GND}
N 2130 -2750 2130 -2680 {lab=V_RES}
N 1180 -2870 1290 -2870 {lab=V_REF_MIR}
N 1290 -2870 1290 -2780 {lab=V_REF_MIR}
N 2130 -3460 2170 -3460 {lab=VDD}
N 2170 -3520 2170 -3460 {lab=VDD}
N 2130 -3520 2170 -3520 {lab=VDD}
N 1140 -3460 1180 -3460 {lab=VDD}
N 1140 -3520 1140 -3460 {lab=VDD}
N 1140 -3520 1180 -3520 {lab=VDD}
N 1140 -2720 1180 -2720 {lab=GND}
N 1140 -2780 1140 -2720 {lab=GND}
N 1140 -2780 1180 -2780 {lab=GND}
N 2130 -2780 2260 -2780 {lab=GND}
N 730 -3120 730 -2950 {lab=START_UP}
N 730 -3250 730 -3180 {lab=VDD}
N 690 -3150 730 -3150 {lab=VDD}
N 690 -3210 690 -3150 {lab=VDD}
N 690 -3210 730 -3210 {lab=VDD}
N 690 -2920 690 -2860 {lab=GND}
N 690 -2920 730 -2920 {lab=GND}
N 920 -3070 990 -3070 {lab=GND}
N 730 -3070 880 -3070 {lab=START_UP}
N 770 -3150 800 -3150 {lab=START_UP}
N 800 -3150 800 -3070 {lab=START_UP}
N 920 -3110 920 -3100 {lab=Vbiasp}
N 920 -3040 920 -3030 {lab=V_REF_MIR}
N 920 -3030 1180 -3030 {lab=V_REF_MIR}
N 2070 -2650 2110 -2650 {lab=GND}
N 2130 -2620 2130 -2540 {lab=GND}
N 770 -2920 1180 -2920 {lab=V_REF_MIR}
N 730 -2890 730 -2810 {lab=GND}
N 730 -2810 730 -2690 {lab=GND}
N 690 -2860 730 -2860 {lab=GND}
N 1430 -3610 1430 -2630 {lab=Vbiasp_MIR}
N 1810 -3610 1810 -2630 {lab=Vbiasp}
N 1470 -3640 1770 -3640 {lab=Vbiasp_MIR}
N 1430 -3740 1430 -3670 {lab=VDD}
N 1810 -3740 1810 -3670 {lab=VDD}
N 1430 -2570 1430 -2500 {lab=GND}
N 1810 -2570 1810 -2500 {lab=GND}
N 1810 -3640 1850 -3640 {lab=VDD}
N 1850 -3700 1850 -3640 {lab=VDD}
N 1810 -3700 1850 -3700 {lab=VDD}
N 1390 -3640 1430 -3640 {lab=VDD}
N 1390 -3700 1390 -3640 {lab=VDD}
N 1390 -3700 1430 -3700 {lab=VDD}
N 1390 -2540 1430 -2540 {lab=GND}
N 1390 -2600 1390 -2540 {lab=GND}
N 1390 -2600 1430 -2600 {lab=GND}
N 1810 -2540 1850 -2540 {lab=GND}
N 1850 -2600 1850 -2540 {lab=GND}
N 1810 -2600 1850 -2600 {lab=GND}
N 1610 -3640 1610 -3530 {lab=Vbiasp_MIR}
N 1430 -3530 1610 -3530 {lab=Vbiasp_MIR}
N 1220 -2780 1290 -2780 {lab=V_REF_MIR}
N 1290 -2780 1640 -2780 {lab=V_REF_MIR}
N 1640 -2780 1770 -2600 {lab=V_REF_MIR}
N 1470 -2600 1710 -2780 {lab=V_REF}
N 1710 -2780 2090 -2780 {lab=V_REF}
N 2010 -2870 2010 -2780 {lab=V_REF}
N 2010 -2870 2130 -2870 {lab=V_REF}
N 1220 -3460 1810 -3460 {lab=Vbiasp}
N 1810 -3460 2090 -3460 {lab=Vbiasp}
N 920 -3110 1810 -3110 {lab=Vbiasp}
N 2530 -2620 2530 -2550 {lab=GND}
N 2490 -2590 2530 -2590 {lab=GND}
N 2490 -2650 2490 -2590 {lab=GND}
N 2490 -2650 2530 -2650 {lab=GND}
N 2530 -3280 2530 -3210 {lab=VDD}
N 2530 -3180 2570 -3180 {lab=VDD}
N 2570 -3240 2570 -3180 {lab=VDD}
N 2530 -3240 2570 -3240 {lab=VDD}
N 2530 -3150 2530 -2680 {lab=Vbias3}
N 4300 -3280 4600 -3280 {lab=Vbias1}
N 4260 -3380 4260 -3310 {lab=VDD}
N 4640 -3380 4640 -3310 {lab=VDD}
N 4640 -3280 4680 -3280 {lab=VDD}
N 4680 -3340 4680 -3280 {lab=VDD}
N 4640 -3340 4680 -3340 {lab=VDD}
N 4220 -3280 4260 -3280 {lab=VDD}
N 4220 -3340 4220 -3280 {lab=VDD}
N 4220 -3340 4260 -3340 {lab=VDD}
N 4440 -3280 4440 -3170 {lab=Vbias1}
N 4260 -2830 4440 -2830 {lab=Vbias1}
N 4300 -3010 4600 -3010 {lab=Vbias2}
N 4260 -3110 4260 -3040 {lab=Vhigh}
N 4640 -3110 4640 -3040 {lab=#net1}
N 4640 -3010 4680 -3010 {lab=VDD}
N 4680 -3070 4680 -3010 {lab=VDD}
N 4220 -3010 4260 -3010 {lab=VDD}
N 4220 -3070 4220 -3010 {lab=VDD}
N 4260 -3250 4260 -3110 {lab=Vhigh}
N 4640 -3250 4640 -3110 {lab=#net1}
N 4440 -3170 4440 -2830 {lab=Vbias1}
N 4260 -2980 4260 -2760 {lab=Vbias1}
N 4640 -2980 4640 -2760 {lab=Vncas}
N 4160 -2920 4360 -2920 {lab=Vbias2}
N 4360 -3010 4360 -2920 {lab=Vbias2}
N 4260 -2330 4260 -2260 {lab=GND}
N 4260 -2300 4300 -2300 {lab=GND}
N 4300 -2360 4300 -2300 {lab=GND}
N 4260 -2360 4300 -2360 {lab=GND}
N 4260 -2450 4260 -2390 {lab=#net2}
N 4070 -2360 4220 -2360 {lab=Vbias4}
N 4640 -2550 4640 -2480 {lab=#net3}
N 4600 -2580 4600 -2520 {lab=GND}
N 4600 -2580 4640 -2580 {lab=GND}
N 4640 -2760 4640 -2610 {lab=Vncas}
N 4640 -2800 4950 -2800 {lab=Vncas}
N 4680 -2580 4770 -2580 {lab=Vncas}
N 4640 -2330 4640 -2260 {lab=#net4}
N 4680 -2360 4680 -2300 {lab=GND}
N 4640 -2360 4680 -2360 {lab=GND}
N 4640 -2480 4640 -2390 {lab=#net3}
N 4640 -2200 4640 -2130 {lab=GND}
N 4640 -2170 4680 -2170 {lab=GND}
N 4680 -2230 4680 -2170 {lab=GND}
N 4640 -2230 4680 -2230 {lab=GND}
N 4510 -2230 4600 -2230 {lab=#net3}
N 4600 -2520 4680 -2520 {lab=GND}
N 4680 -2520 4680 -2360 {lab=GND}
N 4680 -2300 4680 -2230 {lab=GND}
N 4510 -2440 4510 -2230 {lab=#net3}
N 4510 -2440 4640 -2440 {lab=#net3}
N 4220 -3280 4220 -3070 {lab=VDD}
N 4680 -3280 4680 -3070 {lab=VDD}
N 2870 -3280 2870 -3210 {lab=VDD}
N 2870 -3180 2910 -3180 {lab=VDD}
N 2910 -3240 2910 -3180 {lab=VDD}
N 2870 -3240 2910 -3240 {lab=VDD}
N 2870 -3010 2870 -2940 {lab=Vbias4}
N 2870 -3150 2870 -3010 {lab=Vbias4}
N 2870 -2880 2870 -2660 {lab=Vbias4}
N 2830 -2560 2830 -2500 {lab=GND}
N 2870 -2660 2870 -2590 {lab=Vbias4}
N 2830 -2560 2870 -2560 {lab=GND}
N 2870 -2530 2870 -2460 {lab=Vlow}
N 4440 -3210 4950 -3210 {lab=Vbias1}
N 2720 -3180 2720 -3110 {lab=Vbiasp}
N 2720 -3180 2830 -3180 {lab=Vbiasp}
N 2830 -2360 2830 -2300 {lab=GND}
N 2870 -2460 2870 -2390 {lab=Vlow}
N 2830 -2360 2870 -2360 {lab=GND}
N 2870 -2330 2870 -2260 {lab=GND}
N 2830 -2300 2870 -2300 {lab=GND}
N 2910 -2360 2990 -2360 {lab=Vbias4}
N 2990 -2720 2990 -2360 {lab=Vbias4}
N 2870 -2720 2990 -2720 {lab=Vbias4}
N 4360 -2920 4950 -2920 {lab=Vbias2}
N 4770 -2800 4770 -2580 {lab=Vncas}
N 2830 -2500 2830 -2360 {lab=GND}
N 3320 -3280 3320 -3210 {lab=VDD}
N 3320 -3180 3360 -3180 {lab=VDD}
N 3360 -3240 3360 -3180 {lab=VDD}
N 3320 -3240 3360 -3240 {lab=VDD}
N 3320 -3010 3320 -2940 {lab=Vds2}
N 3320 -2910 3360 -2910 {lab=VDD}
N 3360 -2970 3360 -2910 {lab=VDD}
N 3320 -3150 3320 -3010 {lab=Vds2}
N 3360 -2560 3360 -2500 {lab=GND}
N 3320 -2660 3320 -2590 {lab=Vpcas}
N 3360 -3180 3360 -2970 {lab=VDD}
N 3320 -2560 3360 -2560 {lab=GND}
N 3320 -2530 3320 -2460 {lab=Vds3}
N 3210 -3180 3210 -3110 {lab=Vgs2}
N 3210 -3180 3280 -3180 {lab=Vgs2}
N 3360 -2360 3360 -2300 {lab=GND}
N 3320 -2460 3320 -2390 {lab=Vds3}
N 3320 -2360 3360 -2360 {lab=GND}
N 3320 -2330 3320 -2260 {lab=GND}
N 3320 -2300 3360 -2300 {lab=GND}
N 3200 -2360 3280 -2360 {lab=Vbias4}
N 3110 -2910 3280 -2910 {lab=Vbias2}
N 3360 -2500 3360 -2360 {lab=GND}
N 2990 -2360 3200 -2360 {lab=Vbias4}
N 2910 -2560 3280 -2560 {lab=Vbias3}
N 3110 -2650 3110 -2560 {lab=Vbias3}
N 3320 -2780 3360 -2780 {lab=VDD}
N 3360 -2840 3360 -2780 {lab=VDD}
N 3210 -2780 3210 -2690 {lab=Vpcas}
N 3210 -2780 3280 -2780 {lab=Vpcas}
N 3360 -2910 3360 -2840 {lab=VDD}
N 3320 -2880 3320 -2810 {lab=Vgs2}
N 3210 -3110 3210 -2850 {lab=Vgs2}
N 3210 -2850 3320 -2850 {lab=Vgs2}
N 3320 -2750 3320 -2660 {lab=Vpcas}
N 3210 -2690 3320 -2690 {lab=Vpcas}
N 3320 -2690 3580 -2690 {lab=Vpcas}
N 4410 -2360 4600 -2360 {lab=Vbias3}
N 2390 -3110 2420 -3110 {lab=Vbiasp}
N 3110 -2650 3580 -2650 {lab=Vbias3}
N 2870 -2490 3580 -2490 {lab=Vlow}
N 2990 -2440 3580 -2440 {lab=Vbias4}
N 4260 -3130 4950 -3130 {lab=Vhigh}
N 1980 -3460 1980 -3370 {lab=Vbiasp}
N 2410 -3180 2490 -3180 {lab=Vbiasp}
N 1980 -3180 2410 -3180 {lab=Vbiasp}
N 1980 -3370 1980 -3180 {lab=Vbiasp}
N 2870 -2940 2870 -2880 {lab=Vbias4}
N 2570 -2650 2780 -2650 {lab=Vbias3}
N 2640 -2760 2640 -2650 {lab=Vbias3}
N 2530 -2760 2640 -2760 {lab=Vbias3}
N 2420 -3110 2720 -3110 {lab=Vbiasp}
N 2390 -3180 2390 -3110 {lab=Vbiasp}
N 2780 -2650 3110 -2650 {lab=Vbias3}
N 4260 -2540 4260 -2450 {lab=#net2}
N 4260 -2570 4300 -2570 {lab=GND}
N 4260 -2760 4260 -2600 {lab=Vbias1}
N 4300 -2570 4300 -2360 {lab=GND}
N 4070 -2570 4220 -2570 {lab=Vbias3}
N 3870 -2920 3910 -2920 {lab=VDD}
N 3910 -2890 3910 -2760 {lab=Vbias2}
N 3910 -2330 3910 -2260 {lab=GND}
N 3910 -2300 3950 -2300 {lab=GND}
N 3950 -2360 3950 -2300 {lab=GND}
N 3910 -2360 3950 -2360 {lab=GND}
N 3910 -2450 3910 -2390 {lab=#net5}
N 3720 -2360 3870 -2360 {lab=Vbias4}
N 3910 -2540 3910 -2450 {lab=#net5}
N 3910 -2570 3950 -2570 {lab=GND}
N 3910 -2760 3910 -2600 {lab=Vbias2}
N 3950 -2570 3950 -2360 {lab=GND}
N 3720 -2570 3870 -2570 {lab=Vbias3}
N 3910 -3020 3910 -2950 {lab=VDD}
N 3870 -2980 3870 -2920 {lab=VDD}
N 3870 -2980 3910 -2980 {lab=VDD}
N 3950 -2920 4160 -2920 {lab=Vbias2}
N 4000 -2920 4000 -2830 {lab=Vbias2}
N 3910 -2830 4000 -2830 {lab=Vbias2}
N 3580 -2650 3720 -2650 {lab=Vbias3}
N 3720 -2650 3720 -2570 {lab=Vbias3}
N 3580 -2440 3720 -2440 {lab=Vbias4}
N 3720 -2440 3720 -2360 {lab=Vbias4}
N 4070 -2650 4070 -2570 {lab=Vbias3}
N 4070 -2440 4070 -2360 {lab=Vbias4}
N 3720 -2440 4070 -2440 {lab=Vbias4}
N 3720 -2650 4070 -2650 {lab=Vbias3}
N 4070 -2650 4410 -2650 {lab=Vbias3}
N 4410 -2650 4410 -2360 {lab=Vbias3}
N 2300 -3410 2300 -3320 {lab=VDD}
N 2300 -3260 2300 -3180 {lab=Vbiasp}
N 7440 -2950 7740 -2950 {lab=ST_AMP_MIR}
N 7780 -3430 7780 -3360 {lab=ST_Vp}
N 7400 -3430 7400 -3360 {lab=ST_Vp}
N 7780 -3300 7780 -3220 {lab=ST_VD1}
N 7400 -3300 7400 -3220 {lab=ST_VD2}
N 7400 -3160 7400 -2980 {lab=ST_AMP_OUT}
N 7780 -3160 7780 -2980 {lab=ST_AMP_MIR}
N 7400 -2850 7780 -2850 {lab=GND}
N 7600 -2850 7600 -2820 {lab=GND}
N 7820 -3330 7880 -3330 {lab=V_SAWTOOTH}
N 7290 -3330 7360 -3330 {lab=ST_V_REF}
N 7600 -3030 7780 -3030 {lab=ST_AMP_MIR}
N 7600 -3030 7600 -2950 {lab=ST_AMP_MIR}
N 7850 -2950 7850 -2850 {lab=GND}
N 7780 -2850 7850 -2850 {lab=GND}
N 7780 -2950 7850 -2950 {lab=GND}
N 7330 -2950 7330 -2850 {lab=GND}
N 7330 -2850 7400 -2850 {lab=GND}
N 7330 -2950 7400 -2950 {lab=GND}
N 7850 -3190 7850 -2950 {lab=GND}
N 7330 -3190 7330 -2950 {lab=GND}
N 7400 -3190 7780 -3190 {lab=VDD}
N 7400 -3330 7780 -3330 {lab=VDD}
N 7550 -3330 7550 -3190 {lab=VDD}
N 7780 -2920 7780 -2850 {lab=GND}
N 7400 -2920 7400 -2850 {lab=GND}
N 6880 -2950 6880 -2850 {lab=GND}
N 6880 -2850 6920 -2850 {lab=GND}
N 6880 -2950 6920 -2950 {lab=GND}
N 6920 -2920 6920 -2850 {lab=GND}
N 5780 -2950 5780 -2850 {lab=GND}
N 5780 -2850 5820 -2850 {lab=GND}
N 5780 -2950 5820 -2950 {lab=GND}
N 5820 -2920 5820 -2850 {lab=GND}
N 7280 -3030 7280 -2950 {lab=ST_AMP_OUT}
N 6960 -2950 7280 -2950 {lab=ST_AMP_OUT}
N 6920 -3510 6920 -2980 {lab=ST_PULL_DOWN}
N 5910 -3030 5910 -2950 {lab=ST_PULL_DOWN2}
N 5860 -2950 5910 -2950 {lab=ST_PULL_DOWN2}
N 5820 -3160 5820 -2980 {lab=S_RST}
N 5910 -3190 5910 -3030 {lab=ST_PULL_DOWN2}
N 5860 -3190 5910 -3190 {lab=ST_PULL_DOWN2}
N 5910 -3080 6240 -3080 {lab=ST_PULL_DOWN2}
N 5780 -3260 5780 -3190 {lab=VDD}
N 5780 -3190 5820 -3190 {lab=VDD}
N 5820 -3260 5820 -3220 {lab=VDD}
N 5780 -3260 5820 -3260 {lab=VDD}
N 5820 -3310 5820 -3260 {lab=VDD}
N 7400 -3430 7780 -3430 {lab=ST_Vp}
N 7590 -3510 7590 -3430 {lab=ST_Vp}
N 5750 -3080 5820 -3080 {lab=S_RST}
N 7820 -3190 7850 -3190 {lab=GND}
N 7330 -3190 7360 -3190 {lab=GND}
N 6920 -2850 7330 -2850 {lab=GND}
N 5820 -2850 6880 -2850 {lab=GND}
N 7550 -3540 7590 -3540 {lab=VDD}
N 7630 -3540 7670 -3540 {lab=Vbias1}
N 7670 -3540 7770 -3540 {lab=Vbias1}
N 7880 -3330 7940 -3330 {lab=V_SAWTOOTH}
N 7550 -3540 7550 -3330 {lab=VDD}
N 7550 -3620 7590 -3620 {lab=VDD}
N 7590 -3660 7590 -3570 {lab=VDD}
N 7550 -3620 7550 -3540 {lab=VDD}
N 6880 -3540 6920 -3540 {lab=VDD}
N 6960 -3540 7000 -3540 {lab=Vbias1}
N 7000 -3540 7050 -3540 {lab=Vbias1}
N 6880 -3620 6880 -3540 {lab=VDD}
N 6920 -3660 6920 -3570 {lab=#net6}
N 7280 -3030 7400 -3030 {lab=ST_AMP_OUT}
N 5730 -3080 5750 -3080 {lab=S_RST}
N 8120 -3140 8120 -3040 {lab=GND}
N 8320 -3100 8360 -3100 {lab=GND}
N 8360 -3140 8360 -3100 {lab=GND}
N 8120 -3100 8320 -3100 {lab=GND}
N 8120 -3330 8360 -3330 {lab=V_SAWTOOTH}
N 8360 -3330 8360 -3200 {lab=V_SAWTOOTH}
N 8060 -3330 8120 -3330 {lab=V_SAWTOOTH}
N 8270 -3170 8360 -3170 {lab=GND}
N 8120 -3240 8120 -3200 {lab=#net7}
N 8120 -3330 8120 -3300 {lab=V_SAWTOOTH}
N 7940 -3330 8060 -3330 {lab=V_SAWTOOTH}
N 5730 -3080 5730 -2680 {lab=S_RST}
N 5730 -2680 8330 -2680 {lab=S_RST}
N 8490 -3170 8490 -2680 {lab=S_RST}
N 8400 -3170 8490 -3170 {lab=S_RST}
N 8240 -3410 8240 -3330 {lab=V_SAWTOOTH}
N 8200 -3440 8240 -3440 {lab=VDD}
N 8280 -3440 8320 -3440 {lab=Vbias1}
N 8320 -3440 8420 -3440 {lab=Vbias1}
N 8020 -3750 8020 -3330 {lab=V_SAWTOOTH}
N 8240 -3530 8240 -3470 {lab=#net8}
N 8200 -3560 8240 -3560 {lab=VDD}
N 8240 -3680 8240 -3590 {lab=#net9}
N 8200 -3560 8200 -3440 {lab=VDD}
N 8200 -3890 8240 -3890 {lab=VDD}
N 8240 -4010 8240 -3920 {lab=VDD}
N 8200 -3710 8200 -3560 {lab=VDD}
N 8200 -4010 8200 -3890 {lab=VDD}
N 8200 -4010 8240 -4010 {lab=VDD}
N 8240 -4040 8240 -4010 {lab=VDD}
N 8330 -3560 8330 -3440 {lab=Vbias1}
N 8280 -3560 8330 -3560 {lab=Vbias1}
N 8330 -3710 8330 -3560 {lab=Vbias1}
N 8280 -3890 8330 -3890 {lab=Vbias1}
N 8200 -3740 8240 -3740 {lab=VDD}
N 8240 -3860 8240 -3770 {lab=#net10}
N 8200 -3890 8200 -3740 {lab=VDD}
N 8280 -3740 8330 -3740 {lab=Vbias1}
N 8330 -3890 8330 -3740 {lab=Vbias1}
N 8200 -3740 8200 -3710 {lab=VDD}
N 8240 -3710 8240 -3680 {lab=#net9}
N 8330 -3740 8330 -3710 {lab=Vbias1}
N 8330 -2680 8490 -2680 {lab=S_RST}
N 6320 -3180 6320 -3020 {lab=ST_PULL_DOWN2}
N 6380 -3180 6380 -3020 {lab=#net11}
N 6350 -2980 6350 -2950 {lab=VDD}
N 6350 -3250 6350 -3220 {lab=GND}
N 6350 -3040 6350 -3020 {lab=GND}
N 6350 -3040 6400 -3040 {lab=GND}
N 6400 -3240 6400 -3040 {lab=GND}
N 6350 -3240 6400 -3240 {lab=GND}
N 6350 -3180 6350 -3160 {lab=VDD}
N 6300 -3160 6350 -3160 {lab=VDD}
N 6300 -3160 6300 -2970 {lab=VDD}
N 6300 -2970 6350 -2970 {lab=VDD}
N 6470 -3180 6470 -3020 {lab=#net11}
N 6530 -3180 6530 -3020 {lab=#net12}
N 6500 -2980 6500 -2950 {lab=VDD}
N 6500 -3250 6500 -3220 {lab=GND}
N 6500 -3040 6500 -3020 {lab=GND}
N 6500 -3040 6550 -3040 {lab=GND}
N 6550 -3240 6550 -3040 {lab=GND}
N 6500 -3240 6550 -3240 {lab=GND}
N 6500 -3180 6500 -3160 {lab=VDD}
N 6450 -3160 6500 -3160 {lab=VDD}
N 6450 -3160 6450 -2970 {lab=VDD}
N 6450 -2970 6500 -2970 {lab=VDD}
N 6380 -3080 6470 -3080 {lab=#net11}
N 6620 -3180 6620 -3020 {lab=#net12}
N 6680 -3180 6680 -3020 {lab=#net13}
N 6650 -2980 6650 -2950 {lab=VDD}
N 6650 -3250 6650 -3220 {lab=GND}
N 6650 -3040 6650 -3020 {lab=GND}
N 6650 -3040 6700 -3040 {lab=GND}
N 6700 -3240 6700 -3040 {lab=GND}
N 6650 -3240 6700 -3240 {lab=GND}
N 6650 -3180 6650 -3160 {lab=VDD}
N 6600 -3160 6650 -3160 {lab=VDD}
N 6600 -3160 6600 -2970 {lab=VDD}
N 6600 -2970 6650 -2970 {lab=VDD}
N 6530 -3080 6620 -3080 {lab=#net12}
N 6240 -3080 6260 -3080 {lab=ST_PULL_DOWN2}
N 6260 -3080 6320 -3080 {lab=ST_PULL_DOWN2}
N 6880 -3690 6920 -3690 {lab=VDD}
N 6960 -3690 7000 -3690 {lab=Vbias1}
N 6880 -3770 6880 -3690 {lab=VDD}
N 6920 -3810 6920 -3720 {lab=#net14}
N 6880 -3840 6920 -3840 {lab=VDD}
N 6960 -3840 7000 -3840 {lab=Vbias1}
N 6880 -3920 6920 -3920 {lab=VDD}
N 6880 -3920 6880 -3840 {lab=VDD}
N 6920 -3960 6920 -3870 {lab=VDD}
N 6880 -3840 6880 -3770 {lab=VDD}
N 7000 -3840 7000 -3690 {lab=Vbias1}
N 6880 -3690 6880 -3620 {lab=VDD}
N 7000 -3690 7000 -3540 {lab=Vbias1}
N 6820 -3080 6920 -3080 {lab=ST_PULL_DOWN}
N 6680 -3080 6760 -3080 {lab=#net13}
C {devices/vsource.sym} 5590 -2270 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 5590 -2220 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 5590 -2320 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 5370 -2320 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 8830 -3520 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

* .include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.save
+v(vbias1)
+v(vbias2)
+v(vbias3)
+v(vbias4)
+v(pwm_v_p)
+v(pwm_vd1)
+v(pwm_vd2)
+v(pwm_amp_mir)
+v(pwm_amp_out)
+v(pwm_pull_down)
+v(st_v_p)
+v(st_vd1)
+v(st_vd2)
+v(st_amp_mir)
+v(st_amp_out)
+v(st_pull_down)
+v(st_v_p)
+v(st_v_ref)
+v(st_vd1)
+v(st_vd2)
+v(st_amp_mir)
+v(st_amp_out)
+v(st_pull_down)
+v(st_pull_down2)
+v(s_rst)
+v(v_sawtooth)
+v(err_amp_mir)
+v(err_amp_out)
+v(err_amp_vp)
+v(err_amp_vd1)
+v(err_amp_vd2)
+v(err_amp_vb1)
+v(err_v_tail_btw)

+v(clk_out)
.control
  * save all
  * dc V1 0.0 2.0 0.005
  tran 0.5ns 20us
  remzerovec
  write tb_PWM_gen_8.raw
  set appendwrite

.endc


"
}
C {devices/vsource.sym} 5690 -2260 0 0 {name=V2 value=1.60 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 5690 -2230 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 5690 -2340 0 1 {name=p22 lab=ST_V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2110 -2780 0 0 {name=M1
W=16
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1200 -2780 0 1 {name=M2
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 -2920 0 1 {name=M5
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 900 -3070 0 0 {name=M7
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 -2540 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 2070 -2650 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 1180 -2680 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 730 -2690 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 990 -3070 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 2260 -2780 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 730 -3250 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 1180 -3560 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 2130 -3560 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 2130 -2710 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 730 -3070 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 750 -3150 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2110 -3460 0 0 {name=M3
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1200 -3460 0 1 {name=M4
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 2290 -2700 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -2600 0 0 {name=M8
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 -2600 0 1 {name=M9
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1810 -2500 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 1430 -2500 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 1430 -3740 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1810 -3740 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1790 -3640 0 0 {name=M10
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1450 -3640 0 1 {name=M11
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2130 -3050 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2550 -2650 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2550 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2530 -3280 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2510 -3180 0 0 {name=M13
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4260 -3380 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4640 -3380 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3280 0 0 {name=M14
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3280 0 1 {name=M15
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3010 0 0 {name=M16
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3010 0 1 {name=M17
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2360 0 0 {name=M18
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4260 -2260 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4660 -2580 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2360 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2230 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4640 -2130 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2870 -3280 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2850 -3180 0 0 {name=M25
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2560 0 1 {name=M27
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2360 0 1 {name=M28
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2870 -2260 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 3320 -3280 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -3180 0 0 {name=M29
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2910 0 0 {name=M30
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2560 0 0 {name=M31
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2360 0 0 {name=M32
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3320 -2260 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2780 0 0 {name=M33
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4950 -3210 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4950 -3130 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4950 -2920 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4950 -2800 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3580 -2690 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 2390 -3110 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3580 -2650 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3580 -2490 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3580 -2440 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 4410 -2360 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3320 -3060 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 3210 -3060 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 3320 -2460 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 1430 -3320 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 1290 -2870 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2570 0 0 {name=M22
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3930 -2920 0 1 {name=M23
W=12
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2360 0 0 {name=M24
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3910 -2260 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2570 0 0 {name=M26
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3910 -3020 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 3110 -2910 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 -3290 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 2300 -3410 0 1 {name=l28 lab=VDD}
C {sky130_fd_pr/res_high_po_0p35.sym} 2130 -2650 0 0 {name=R1
L=10
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 7600 -2830 0 1 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7760 -2950 0 0 {name=M58
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7420 -2950 0 1 {name=M59
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7380 -3330 0 0 {name=M60
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7800 -3330 0 1 {name=M61
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7380 -3190 0 0 {name=M62
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7800 -3190 0 1 {name=M63
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7400 -3090 0 0 {name=p44 lab=ST_AMP_OUT}
C {lab_pin.sym} 7780 -3090 0 1 {name=p46 lab=ST_AMP_MIR}
C {devices/ngspice_get_value.sym} 7760 -2920 2 0 {name=r33 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7420 -2920 2 1 {name=r34 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7760 -3160 2 0 {name=r35 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7420 -3160 2 1 {name=r36 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7760 -3290 2 0 {name=r37 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7420 -3290 2 1 {name=r38 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -2950 0 1 {name=M64
W=2
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5840 -2950 0 1 {name=M65
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5840 -3190 0 1 {name=M66
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5800 -3160 2 0 {name=r39 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6930 -2920 2 1 {name=r40 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -2920 2 1 {name=r41 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 5820 -3310 0 1 {name=l40 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 7610 -3540 0 1 {name=M67
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7600 -3510 2 1 {name=r42 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7770 -3540 0 1 {name=p48 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 6920 -3080 0 1 {name=p49 sig_type=std_logic lab=ST_PULL_DOWN}
C {devices/vdd.sym} 7590 -3660 0 1 {name=l41 lab=VDD}
C {lab_wire.sym} 7670 -3430 0 1 {name=p50 sig_type=std_logic lab=ST_Vp}
C {sky130_fd_pr/pfet_01v8.sym} 6940 -3540 0 1 {name=M68
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6930 -3510 2 1 {name=r43 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7050 -3540 0 1 {name=p51 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6920 -3960 0 1 {name=l42 lab=VDD}
C {lab_pin.sym} 7400 -3250 0 0 {name=p52 lab=ST_VD2}
C {lab_pin.sym} 7780 -3250 0 1 {name=p53 lab=ST_VD1}
C {lab_pin.sym} 7290 -3330 0 0 {name=p55 lab=ST_V_REF}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8120 -3170 0 1 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=270 spiceprefix=X}
C {devices/gnd.sym} 8120 -3050 0 1 {name=l43 lab=GND}
C {devices/ngspice_get_value.sym} 8370 -3140 2 1 {name=r44 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 8120 -3270 0 1 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 8380 -3170 0 1 {name=M69
W=4.0
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8270 -3170 0 1 {name=l44 lab=GND}
C {lab_wire.sym} 8490 -3170 0 1 {name=p57 sig_type=std_logic lab=S_RST}
C {lab_wire.sym} 7900 -3330 2 0 {name=p58 sig_type=std_logic lab=V_SAWTOOTH}
C {sky130_fd_pr/pfet_01v8.sym} 8260 -3440 0 1 {name=M70
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 8250 -3410 2 1 {name=r45 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8420 -3440 0 1 {name=p47 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 8020 -3750 0 1 {name=p54 sig_type=std_logic lab=V_SAWTOOTH}
C {sky130_fd_pr/pfet_01v8.sym} 8260 -3560 0 1 {name=M35
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8260 -3890 0 1 {name=M34
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 8240 -4040 0 1 {name=l29 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 8260 -3740 0 1 {name=M36
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6350 -3000 3 0 {name=M37
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6350 -3200 3 1 {name=M38
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6350 -2950 2 1 {name=l30 lab=VDD}
C {devices/gnd.sym} 6350 -3250 2 1 {name=l31 lab=GND}
C {lab_wire.sym} 5940 -3080 0 1 {name=p15 sig_type=std_logic lab=ST_PULL_DOWN2}
C {sky130_fd_pr/nfet_01v8.sym} 6500 -3000 3 0 {name=M39
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6500 -3200 3 1 {name=M40
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6500 -2950 2 1 {name=l32 lab=VDD}
C {devices/gnd.sym} 6500 -3250 2 1 {name=l33 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6650 -3000 3 0 {name=M41
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6650 -3200 3 1 {name=M42
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6650 -2950 2 1 {name=l34 lab=VDD}
C {devices/gnd.sym} 6650 -3250 2 1 {name=l35 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 6940 -3690 0 1 {name=M43
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6930 -3660 2 1 {name=r2 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 6940 -3840 0 1 {name=M44
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6930 -3810 2 1 {name=r3 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 6790 -3080 3 1 {name=Vmeas1 savecurrent=true spice_ignore=0}
