v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1220 -750 2130 -110 {flags=graph

y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-1.1e-14









color=7
node=v_ref}
B 2 170 -750 1080 -110 {flags=graph

y2=7.9e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0








color="6 7"
node="i(@m.xm1.msky130_fd_pr__nfet_01v8[id])
i(@m.xm2.msky130_fd_pr__nfet_01v8[id])"}
B 2 2310 -1360 3260 -440 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-3.6e-11









color="6 4 7 9 10 16 17 12"
node="vbias1
vhigh
vbias2
vncas
vpcas
vbias3
vlow
vbias4"}
B 2 3400 -1360 4350 -440 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-3.6e-11









color="6 7 19 12"
node="vbias1
vbias2
vbias3
vbias4"}
B 2 980 -2540 1210 -2380 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.2e-13









color=7
node=v_ref}
B 2 170 -1540 1080 -900 {flags=graph

y2=0.00016
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0








color="6 7"
node="i(@m.xm9.msky130_fd_pr__nfet_01v8[id])
i(@m.xm8.msky130_fd_pr__nfet_01v8[id])"}
B 2 6640 -1630 7300 -1180 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.021











color=7
node=clk_swcap}
B 2 1220 -1540 2130 -900 {flags=graph

y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-1.1e-14









color=7
node=v_ref}
B 2 5830 -1630 6490 -1180 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.00013












color=6
node=s_rst}
B 2 6640 -1110 7300 -660 {flags=graph

y2=0.18
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=6
























y1=0.16












color=7
node=v_ctrl_vtc}
B 2 5830 -1110 6490 -660 {flags=graph

y2=0.24
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.00028












color=6
node=vin_p}
B 2 4830 -2060 5090 -1870 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.1e-05












color=6
node=s_rst}
B 2 4820 -1840 5090 -1650 {flags=graph

y2=2e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.0002












color=6
node=i(vmeas)}
B 2 5060 -1630 5720 -1180 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.83













color=6
node=pull_down}
B 2 6760 -1950 7220 -1700 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=3.9272999e-06
x2=4.442696e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.086











color="7 6 11 18"
node="r
r_b
s_b
net7"}
N 660 -2930 660 -2310 {lab=V_REF_MIR}
N 1610 -2930 1610 -2310 {lab=V_REF}
N 660 -3060 660 -2990 {lab=VDD}
N 1610 -3060 1610 -2990 {lab=VDD}
N 660 -2250 660 -2180 {lab=GND}
N 1610 -2250 1610 -2180 {lab=V_RES}
N 660 -2370 770 -2370 {lab=V_REF_MIR}
N 770 -2370 770 -2280 {lab=V_REF_MIR}
N 1610 -2960 1650 -2960 {lab=VDD}
N 1650 -3020 1650 -2960 {lab=VDD}
N 1610 -3020 1650 -3020 {lab=VDD}
N 620 -2960 660 -2960 {lab=VDD}
N 620 -3020 620 -2960 {lab=VDD}
N 620 -3020 660 -3020 {lab=VDD}
N 620 -2220 660 -2220 {lab=GND}
N 620 -2280 620 -2220 {lab=GND}
N 620 -2280 660 -2280 {lab=GND}
N 1610 -2280 1740 -2280 {lab=GND}
N 210 -2620 210 -2450 {lab=START_UP}
N 210 -2750 210 -2680 {lab=VDD}
N 170 -2650 210 -2650 {lab=VDD}
N 170 -2710 170 -2650 {lab=VDD}
N 170 -2710 210 -2710 {lab=VDD}
N 170 -2420 170 -2360 {lab=GND}
N 170 -2420 210 -2420 {lab=GND}
N 400 -2570 470 -2570 {lab=GND}
N 210 -2570 360 -2570 {lab=START_UP}
N 250 -2650 280 -2650 {lab=START_UP}
N 280 -2650 280 -2570 {lab=START_UP}
N 400 -2610 400 -2600 {lab=Vbiasp}
N 400 -2540 400 -2530 {lab=V_REF_MIR}
N 400 -2530 660 -2530 {lab=V_REF_MIR}
N 1550 -2150 1590 -2150 {lab=GND}
N 1610 -2120 1610 -2040 {lab=GND}
N 250 -2420 660 -2420 {lab=V_REF_MIR}
N 210 -2390 210 -2310 {lab=GND}
N 210 -2310 210 -2190 {lab=GND}
N 170 -2360 210 -2360 {lab=GND}
N 910 -3110 910 -2130 {lab=Vbiasp_MIR}
N 1290 -3110 1290 -2130 {lab=Vbiasp}
N 950 -3140 1250 -3140 {lab=Vbiasp_MIR}
N 910 -3240 910 -3170 {lab=VDD}
N 1290 -3240 1290 -3170 {lab=VDD}
N 910 -2070 910 -2000 {lab=GND}
N 1290 -2070 1290 -2000 {lab=GND}
N 1290 -3140 1330 -3140 {lab=VDD}
N 1330 -3200 1330 -3140 {lab=VDD}
N 1290 -3200 1330 -3200 {lab=VDD}
N 870 -3140 910 -3140 {lab=VDD}
N 870 -3200 870 -3140 {lab=VDD}
N 870 -3200 910 -3200 {lab=VDD}
N 870 -2040 910 -2040 {lab=GND}
N 870 -2100 870 -2040 {lab=GND}
N 870 -2100 910 -2100 {lab=GND}
N 1290 -2040 1330 -2040 {lab=GND}
N 1330 -2100 1330 -2040 {lab=GND}
N 1290 -2100 1330 -2100 {lab=GND}
N 1090 -3140 1090 -3030 {lab=Vbiasp_MIR}
N 910 -3030 1090 -3030 {lab=Vbiasp_MIR}
N 700 -2280 770 -2280 {lab=V_REF_MIR}
N 770 -2280 1120 -2280 {lab=V_REF_MIR}
N 1120 -2280 1250 -2100 {lab=V_REF_MIR}
N 950 -2100 1190 -2280 {lab=V_REF}
N 1190 -2280 1570 -2280 {lab=V_REF}
N 1490 -2370 1490 -2280 {lab=V_REF}
N 1490 -2370 1610 -2370 {lab=V_REF}
N 700 -2960 1290 -2960 {lab=Vbiasp}
N 1290 -2960 1570 -2960 {lab=Vbiasp}
N 400 -2610 1290 -2610 {lab=Vbiasp}
N 2010 -2120 2010 -2050 {lab=GND}
N 1970 -2090 2010 -2090 {lab=GND}
N 1970 -2150 1970 -2090 {lab=GND}
N 1970 -2150 2010 -2150 {lab=GND}
N 2010 -2780 2010 -2710 {lab=VDD}
N 2010 -2680 2050 -2680 {lab=VDD}
N 2050 -2740 2050 -2680 {lab=VDD}
N 2010 -2740 2050 -2740 {lab=VDD}
N 2010 -2650 2010 -2180 {lab=Vbias3}
N 3780 -2780 4080 -2780 {lab=Vbias1}
N 3740 -2880 3740 -2810 {lab=VDD}
N 4120 -2880 4120 -2810 {lab=VDD}
N 4120 -2780 4160 -2780 {lab=VDD}
N 4160 -2840 4160 -2780 {lab=VDD}
N 4120 -2840 4160 -2840 {lab=VDD}
N 3700 -2780 3740 -2780 {lab=VDD}
N 3700 -2840 3700 -2780 {lab=VDD}
N 3700 -2840 3740 -2840 {lab=VDD}
N 3920 -2780 3920 -2670 {lab=Vbias1}
N 3740 -2330 3920 -2330 {lab=Vbias1}
N 3780 -2510 4080 -2510 {lab=Vbias2}
N 3740 -2610 3740 -2540 {lab=Vhigh}
N 4120 -2610 4120 -2540 {lab=#net1}
N 4120 -2510 4160 -2510 {lab=VDD}
N 4160 -2570 4160 -2510 {lab=VDD}
N 3700 -2510 3740 -2510 {lab=VDD}
N 3700 -2570 3700 -2510 {lab=VDD}
N 3740 -2750 3740 -2610 {lab=Vhigh}
N 4120 -2750 4120 -2610 {lab=#net1}
N 3920 -2670 3920 -2330 {lab=Vbias1}
N 3740 -2480 3740 -2260 {lab=Vbias1}
N 4120 -2480 4120 -2260 {lab=Vncas}
N 3640 -2420 3840 -2420 {lab=Vbias2}
N 3840 -2510 3840 -2420 {lab=Vbias2}
N 3740 -1830 3740 -1760 {lab=GND}
N 3740 -1800 3780 -1800 {lab=GND}
N 3780 -1860 3780 -1800 {lab=GND}
N 3740 -1860 3780 -1860 {lab=GND}
N 3740 -1950 3740 -1890 {lab=#net2}
N 3550 -1860 3700 -1860 {lab=Vbias4}
N 4120 -2050 4120 -1980 {lab=Vncas_btw}
N 4080 -2080 4080 -2020 {lab=GND}
N 4080 -2080 4120 -2080 {lab=GND}
N 4120 -2260 4120 -2110 {lab=Vncas}
N 4120 -2300 4430 -2300 {lab=Vncas}
N 4160 -2080 4250 -2080 {lab=Vncas}
N 4120 -1830 4120 -1760 {lab=#net3}
N 4160 -1860 4160 -1800 {lab=GND}
N 4120 -1860 4160 -1860 {lab=GND}
N 4120 -1980 4120 -1890 {lab=Vncas_btw}
N 4120 -1700 4120 -1630 {lab=GND}
N 4120 -1670 4160 -1670 {lab=GND}
N 4160 -1730 4160 -1670 {lab=GND}
N 4120 -1730 4160 -1730 {lab=GND}
N 3990 -1730 4080 -1730 {lab=Vncas_btw}
N 4080 -2020 4160 -2020 {lab=GND}
N 4160 -2020 4160 -1860 {lab=GND}
N 4160 -1800 4160 -1730 {lab=GND}
N 3990 -1940 3990 -1730 {lab=Vncas_btw}
N 3990 -1940 4120 -1940 {lab=Vncas_btw}
N 3700 -2780 3700 -2570 {lab=VDD}
N 4160 -2780 4160 -2570 {lab=VDD}
N 2350 -2780 2350 -2710 {lab=VDD}
N 2350 -2680 2390 -2680 {lab=VDD}
N 2390 -2740 2390 -2680 {lab=VDD}
N 2350 -2740 2390 -2740 {lab=VDD}
N 2350 -2510 2350 -2440 {lab=Vbias4}
N 2350 -2650 2350 -2510 {lab=Vbias4}
N 2350 -2380 2350 -2160 {lab=Vbias4}
N 2310 -2060 2310 -2000 {lab=GND}
N 2350 -2160 2350 -2090 {lab=Vbias4}
N 2310 -2060 2350 -2060 {lab=GND}
N 2350 -2030 2350 -1960 {lab=Vlow}
N 3920 -2710 4430 -2710 {lab=Vbias1}
N 2200 -2680 2200 -2610 {lab=Vbiasp}
N 2200 -2680 2310 -2680 {lab=Vbiasp}
N 2310 -1860 2310 -1800 {lab=GND}
N 2350 -1960 2350 -1890 {lab=Vlow}
N 2310 -1860 2350 -1860 {lab=GND}
N 2350 -1830 2350 -1760 {lab=GND}
N 2310 -1800 2350 -1800 {lab=GND}
N 2390 -1860 2470 -1860 {lab=Vbias4}
N 2470 -2220 2470 -1860 {lab=Vbias4}
N 2350 -2220 2470 -2220 {lab=Vbias4}
N 3840 -2420 4430 -2420 {lab=Vbias2}
N 4250 -2300 4250 -2080 {lab=Vncas}
N 2310 -2000 2310 -1860 {lab=GND}
N 2800 -2780 2800 -2710 {lab=VDD}
N 2800 -2680 2840 -2680 {lab=VDD}
N 2840 -2740 2840 -2680 {lab=VDD}
N 2800 -2740 2840 -2740 {lab=VDD}
N 2800 -2510 2800 -2440 {lab=Vds2}
N 2800 -2410 2840 -2410 {lab=VDD}
N 2840 -2470 2840 -2410 {lab=VDD}
N 2800 -2650 2800 -2510 {lab=Vds2}
N 2840 -2060 2840 -2000 {lab=GND}
N 2800 -2160 2800 -2090 {lab=Vpcas}
N 2840 -2680 2840 -2470 {lab=VDD}
N 2800 -2060 2840 -2060 {lab=GND}
N 2800 -2030 2800 -1960 {lab=Vds3}
N 2690 -2680 2690 -2610 {lab=Vgs2}
N 2690 -2680 2760 -2680 {lab=Vgs2}
N 2840 -1860 2840 -1800 {lab=GND}
N 2800 -1960 2800 -1890 {lab=Vds3}
N 2800 -1860 2840 -1860 {lab=GND}
N 2800 -1830 2800 -1760 {lab=GND}
N 2800 -1800 2840 -1800 {lab=GND}
N 2680 -1860 2760 -1860 {lab=Vbias4}
N 2590 -2410 2760 -2410 {lab=Vbias2}
N 2840 -2000 2840 -1860 {lab=GND}
N 2470 -1860 2680 -1860 {lab=Vbias4}
N 2390 -2060 2760 -2060 {lab=Vbias3}
N 2590 -2150 2590 -2060 {lab=Vbias3}
N 2800 -2280 2840 -2280 {lab=VDD}
N 2840 -2340 2840 -2280 {lab=VDD}
N 2690 -2280 2690 -2190 {lab=Vpcas}
N 2690 -2280 2760 -2280 {lab=Vpcas}
N 2840 -2410 2840 -2340 {lab=VDD}
N 2800 -2380 2800 -2310 {lab=Vgs2}
N 2690 -2610 2690 -2350 {lab=Vgs2}
N 2690 -2350 2800 -2350 {lab=Vgs2}
N 2800 -2250 2800 -2160 {lab=Vpcas}
N 2690 -2190 2800 -2190 {lab=Vpcas}
N 2800 -2190 3060 -2190 {lab=Vpcas}
N 3890 -1860 4080 -1860 {lab=Vbias3}
N 1870 -2610 1900 -2610 {lab=Vbiasp}
N 2590 -2150 3060 -2150 {lab=Vbias3}
N 2350 -1990 3060 -1990 {lab=Vlow}
N 2470 -1940 3060 -1940 {lab=Vbias4}
N 3740 -2630 4430 -2630 {lab=Vhigh}
N 1460 -2960 1460 -2870 {lab=Vbiasp}
N 1890 -2680 1970 -2680 {lab=Vbiasp}
N 1460 -2680 1890 -2680 {lab=Vbiasp}
N 1460 -2870 1460 -2680 {lab=Vbiasp}
N 2350 -2440 2350 -2380 {lab=Vbias4}
N 2050 -2150 2260 -2150 {lab=Vbias3}
N 2120 -2260 2120 -2150 {lab=Vbias3}
N 2010 -2260 2120 -2260 {lab=Vbias3}
N 1900 -2610 2200 -2610 {lab=Vbiasp}
N 1870 -2680 1870 -2610 {lab=Vbiasp}
N 2260 -2150 2590 -2150 {lab=Vbias3}
N 3740 -2040 3740 -1950 {lab=#net2}
N 3740 -2070 3780 -2070 {lab=GND}
N 3740 -2260 3740 -2100 {lab=Vbias1}
N 3780 -2070 3780 -1860 {lab=GND}
N 3550 -2070 3700 -2070 {lab=Vbias3}
N 3350 -2420 3390 -2420 {lab=VDD}
N 3390 -2390 3390 -2260 {lab=Vbias2}
N 3390 -1830 3390 -1760 {lab=GND}
N 3390 -1800 3430 -1800 {lab=GND}
N 3430 -1860 3430 -1800 {lab=GND}
N 3390 -1860 3430 -1860 {lab=GND}
N 3390 -1950 3390 -1890 {lab=#net4}
N 3200 -1860 3350 -1860 {lab=Vbias4}
N 3390 -2040 3390 -1950 {lab=#net4}
N 3390 -2070 3430 -2070 {lab=GND}
N 3390 -2260 3390 -2100 {lab=Vbias2}
N 3430 -2070 3430 -1860 {lab=GND}
N 3200 -2070 3350 -2070 {lab=Vbias3}
N 3390 -2520 3390 -2450 {lab=VDD}
N 3350 -2480 3350 -2420 {lab=VDD}
N 3350 -2480 3390 -2480 {lab=VDD}
N 3430 -2420 3640 -2420 {lab=Vbias2}
N 3480 -2420 3480 -2330 {lab=Vbias2}
N 3390 -2330 3480 -2330 {lab=Vbias2}
N 3060 -2150 3200 -2150 {lab=Vbias3}
N 3200 -2150 3200 -2070 {lab=Vbias3}
N 3060 -1940 3200 -1940 {lab=Vbias4}
N 3200 -1940 3200 -1860 {lab=Vbias4}
N 3550 -2150 3550 -2070 {lab=Vbias3}
N 3550 -1940 3550 -1860 {lab=Vbias4}
N 3200 -1940 3550 -1940 {lab=Vbias4}
N 3200 -2150 3550 -2150 {lab=Vbias3}
N 3550 -2150 3890 -2150 {lab=Vbias3}
N 3890 -2150 3890 -1860 {lab=Vbias3}
N 1780 -2910 1780 -2820 {lab=VDD}
N 1780 -2760 1780 -2680 {lab=Vbiasp}
N 5490 -2040 5790 -2040 {lab=AMP_MIR}
N 5450 -2520 5450 -2450 {lab=Vp}
N 5830 -2520 5830 -2450 {lab=Vp}
N 5450 -2390 5450 -2310 {lab=#net5}
N 5830 -2390 5830 -2310 {lab=#net6}
N 5830 -2250 5830 -2070 {lab=AMP_OUT}
N 5450 -2250 5450 -2070 {lab=AMP_MIR}
N 5450 -1940 5830 -1940 {lab=GND}
N 5630 -1940 5630 -1880 {lab=GND}
N 5350 -2420 5410 -2420 {lab=VIN_P}
N 5870 -2420 5940 -2420 {lab=V_CTRL_VTC}
N 7390 -980 7390 -930 {lab=V_CTRL_VTC}
N 5450 -2120 5630 -2120 {lab=AMP_MIR}
N 5630 -2120 5630 -2040 {lab=AMP_MIR}
N 5380 -2040 5380 -1940 {lab=GND}
N 5380 -1940 5450 -1940 {lab=GND}
N 5380 -2040 5450 -2040 {lab=GND}
N 5900 -2040 5900 -1940 {lab=GND}
N 5830 -1940 5900 -1940 {lab=GND}
N 5830 -2040 5900 -2040 {lab=GND}
N 5380 -2280 5380 -2040 {lab=GND}
N 5900 -2280 5900 -2040 {lab=GND}
N 5450 -2280 5830 -2280 {lab=VDD}
N 5450 -2420 5830 -2420 {lab=VDD}
N 5680 -2420 5680 -2280 {lab=VDD}
N 5450 -2010 5450 -1940 {lab=GND}
N 5830 -2010 5830 -1940 {lab=GND}
N 6160 -2040 6160 -1940 {lab=GND}
N 6120 -1940 6160 -1940 {lab=GND}
N 6120 -2040 6160 -2040 {lab=GND}
N 6120 -2010 6120 -1940 {lab=GND}
N 6460 -2040 6460 -1940 {lab=GND}
N 6420 -1940 6460 -1940 {lab=GND}
N 6420 -2040 6460 -2040 {lab=GND}
N 6420 -2010 6420 -1940 {lab=GND}
N 5950 -2120 5950 -2040 {lab=AMP_OUT}
N 5950 -2040 6080 -2040 {lab=AMP_OUT}
N 6120 -2600 6120 -2070 {lab=PULL_DOWN}
N 6330 -2120 6330 -2040 {lab=PULL_DOWN}
N 6330 -2040 6380 -2040 {lab=PULL_DOWN}
N 6420 -2250 6420 -2070 {lab=S_RST}
N 6330 -2280 6330 -2120 {lab=PULL_DOWN}
N 6330 -2280 6380 -2280 {lab=PULL_DOWN}
N 6120 -2170 6330 -2170 {lab=PULL_DOWN}
N 6460 -2350 6460 -2280 {lab=VDD}
N 6420 -2280 6460 -2280 {lab=VDD}
N 6420 -2350 6420 -2310 {lab=VDD}
N 6420 -2350 6460 -2350 {lab=VDD}
N 6420 -2400 6420 -2350 {lab=VDD}
N 5450 -2520 5830 -2520 {lab=Vp}
N 5640 -2600 5640 -2520 {lab=Vp}
N 6420 -2170 6560 -2170 {lab=S_RST}
N 5380 -2280 5410 -2280 {lab=GND}
N 5870 -2280 5900 -2280 {lab=GND}
N 5140 -2140 5140 -2040 {lab=GND}
N 5900 -1940 6120 -1940 {lab=GND}
N 6160 -1940 6420 -1940 {lab=GND}
N 4900 -2100 4940 -2100 {lab=GND}
N 4900 -2140 4900 -2100 {lab=GND}
N 4940 -2100 5140 -2100 {lab=GND}
N 4900 -2330 5140 -2330 {lab=VIN_P}
N 4900 -2330 4900 -2200 {lab=VIN_P}
N 4750 -2170 4860 -2170 {lab=S_RST}
N 4990 -2400 4990 -2330 {lab=VIN_P}
N 4990 -2430 5030 -2430 {lab=VDD}
N 4910 -2430 4950 -2430 {lab=Vbias1}
N 5030 -2500 5030 -2430 {lab=VDD}
N 4810 -2430 4910 -2430 {lab=Vbias1}
N 7010 -2380 7080 -2380 {lab=S_B}
N 7010 -2090 7080 -2090 {lab=R_B}
N 7050 -2340 7080 -2340 {lab=CLK_SWCAP}
N 7050 -2340 7050 -2320 {lab=CLK_SWCAP}
N 7050 -2320 7230 -2130 {lab=CLK_SWCAP}
N 7230 -2130 7230 -2110 {lab=CLK_SWCAP}
N 7200 -2110 7230 -2110 {lab=CLK_SWCAP}
N 7050 -2130 7080 -2130 {lab=#net7}
N 7050 -2150 7050 -2130 {lab=#net7}
N 7050 -2150 7230 -2340 {lab=#net7}
N 7230 -2360 7230 -2340 {lab=#net7}
N 7200 -2360 7230 -2360 {lab=#net7}
N 6860 -2360 6890 -2360 {lab=S_RST}
N 6860 -2360 6860 -2110 {lab=S_RST}
N 6860 -2110 6890 -2110 {lab=S_RST}
N 6780 -2400 6890 -2400 {lab=CLK_SWCAP}
N 6830 -2070 6890 -2070 {lab=R}
N 6690 -2400 6780 -2400 {lab=CLK_SWCAP}
N 6690 -2070 6750 -2070 {lab=CLK_SWCAP}
N 6690 -2400 6690 -2070 {lab=CLK_SWCAP}
N 6560 -2170 6860 -2170 {lab=S_RST}
N 7230 -2110 7350 -2110 {lab=CLK_SWCAP}
N 6690 -2530 6690 -2400 {lab=CLK_SWCAP}
N 6690 -2530 7280 -2530 {lab=CLK_SWCAP}
N 7280 -2530 7280 -2110 {lab=CLK_SWCAP}
N 5640 -2630 5680 -2630 {lab=VDD}
N 5560 -2630 5600 -2630 {lab=Vbias1}
N 5460 -2630 5560 -2630 {lab=Vbias1}
N 6580 -2170 6580 -1780 {lab=S_RST}
N 5140 -2330 5200 -2330 {lab=VIN_P}
N 5200 -2420 5200 -2330 {lab=VIN_P}
N 5200 -2420 5350 -2420 {lab=VIN_P}
N 4990 -2550 4990 -2460 {lab=#net8}
N 5680 -2700 5680 -2630 {lab=VDD}
N 5640 -2750 5640 -2660 {lab=#net9}
N 4900 -2170 4990 -2170 {lab=GND}
N 5680 -2630 5680 -2420 {lab=VDD}
N 5640 -2780 5680 -2780 {lab=VDD}
N 5640 -2900 5640 -2810 {lab=#net10}
N 5640 -2930 5680 -2930 {lab=VDD}
N 5640 -3050 5640 -2960 {lab=#net11}
N 5680 -2930 5680 -2700 {lab=VDD}
N 5640 -3160 5680 -3160 {lab=VDD}
N 5680 -3010 5680 -2930 {lab=VDD}
N 5550 -2930 5600 -2930 {lab=Vbias1}
N 5550 -2780 5600 -2780 {lab=Vbias1}
N 4990 -2580 5030 -2580 {lab=VDD}
N 4990 -2700 4990 -2610 {lab=#net12}
N 4990 -2730 5030 -2730 {lab=VDD}
N 4990 -2850 4990 -2760 {lab=#net13}
N 5030 -2730 5030 -2500 {lab=VDD}
N 5030 -2810 5030 -2730 {lab=VDD}
N 4900 -2730 4950 -2730 {lab=Vbias1}
N 4900 -2580 4950 -2580 {lab=Vbias1}
N 5640 -3080 5680 -3080 {lab=VDD}
N 5640 -3200 5640 -3110 {lab=VDD}
N 5680 -3080 5680 -3010 {lab=VDD}
N 5550 -3080 5550 -2930 {lab=Vbias1}
N 5550 -3080 5600 -3080 {lab=Vbias1}
N 5680 -3160 5680 -3080 {lab=VDD}
N 5550 -2930 5550 -2780 {lab=Vbias1}
N 5550 -2780 5550 -2630 {lab=Vbias1}
N 4900 -2580 4900 -2430 {lab=Vbias1}
N 4900 -2730 4900 -2580 {lab=Vbias1}
N 4990 -2880 5030 -2880 {lab=VDD}
N 5030 -2880 5030 -2810 {lab=VDD}
N 4900 -2880 4900 -2730 {lab=Vbias1}
N 4900 -2880 4950 -2880 {lab=Vbias1}
N 5030 -2960 5030 -2880 {lab=VDD}
N 4990 -3000 4990 -2910 {lab=#net14}
N 4990 -3110 5030 -3110 {lab=VDD}
N 4990 -3030 5030 -3030 {lab=VDD}
N 5030 -3030 5030 -2960 {lab=VDD}
N 4900 -3030 4900 -2880 {lab=Vbias1}
N 4900 -3030 4950 -3030 {lab=Vbias1}
N 5030 -3110 5030 -3030 {lab=VDD}
N 4990 -3150 4990 -3060 {lab=VDD}
N 6120 -2630 6160 -2630 {lab=VDD}
N 6040 -2630 6080 -2630 {lab=Vbias1}
N 6160 -2700 6160 -2630 {lab=VDD}
N 5940 -2630 6040 -2630 {lab=Vbias1}
N 6120 -2750 6120 -2660 {lab=#net15}
N 6120 -2780 6160 -2780 {lab=VDD}
N 6120 -2900 6120 -2810 {lab=#net16}
N 6120 -2930 6160 -2930 {lab=VDD}
N 6120 -3050 6120 -2960 {lab=#net17}
N 6160 -2930 6160 -2700 {lab=VDD}
N 6160 -3010 6160 -2930 {lab=VDD}
N 6030 -2930 6080 -2930 {lab=Vbias1}
N 6030 -2780 6080 -2780 {lab=Vbias1}
N 6030 -2780 6030 -2630 {lab=Vbias1}
N 6030 -2930 6030 -2780 {lab=Vbias1}
N 6120 -3080 6160 -3080 {lab=VDD}
N 6160 -3080 6160 -3010 {lab=VDD}
N 6030 -3080 6030 -2930 {lab=Vbias1}
N 6030 -3080 6080 -3080 {lab=Vbias1}
N 6160 -3160 6160 -3080 {lab=VDD}
N 6120 -3200 6120 -3110 {lab=#net18}
N 6120 -3760 6160 -3760 {lab=VDD}
N 6120 -3680 6160 -3680 {lab=VDD}
N 6160 -3680 6160 -3610 {lab=VDD}
N 6030 -3680 6030 -3530 {lab=Vbias1}
N 6030 -3680 6080 -3680 {lab=Vbias1}
N 6160 -3760 6160 -3680 {lab=VDD}
N 6120 -3800 6120 -3710 {lab=VDD}
N 6120 -3230 6160 -3230 {lab=VDD}
N 6120 -3350 6120 -3260 {lab=#net19}
N 6120 -3380 6160 -3380 {lab=VDD}
N 6120 -3500 6120 -3410 {lab=#net20}
N 6160 -3460 6160 -3380 {lab=VDD}
N 6030 -3380 6080 -3380 {lab=Vbias1}
N 6030 -3230 6080 -3230 {lab=Vbias1}
N 6030 -3230 6030 -3080 {lab=Vbias1}
N 6030 -3380 6030 -3230 {lab=Vbias1}
N 6120 -3530 6160 -3530 {lab=VDD}
N 6160 -3530 6160 -3460 {lab=VDD}
N 6030 -3530 6030 -3380 {lab=Vbias1}
N 6030 -3530 6080 -3530 {lab=Vbias1}
N 6160 -3610 6160 -3530 {lab=VDD}
N 6120 -3650 6120 -3560 {lab=#net21}
N 6160 -3380 6160 -3160 {lab=VDD}
N 5140 -2240 5140 -2200 {lab=#net22}
N 5140 -2330 5140 -2300 {lab=VIN_P}
N 4750 -2090 4750 -1780 {lab=S_RST}
N 4750 -2170 4750 -2090 {lab=S_RST}
N 4750 -1780 6230 -1780 {lab=S_RST}
N 6230 -1780 6580 -1780 {lab=S_RST}
N 5830 -2120 5950 -2120 {lab=AMP_OUT}
N 8060 -1270 8060 -1210 {lab=VDD}
N 8060 -1150 8060 -1090 {lab=GND}
C {devices/vsource.sym} 8060 -1180 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 8060 -1090 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 8060 -1270 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 7620 -1190 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 7850 -2930 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.save
+@m.xm34.msky130_fd_pr__nfet_01v8[gm]
+@m.xm34.msky130_fd_pr__nfet_01v8[vth]
+@m.xm35.msky130_fd_pr__nfet_01v8[gm]
+@m.xm35.msky130_fd_pr__nfet_01v8[vth]
+@m.xm36.msky130_fd_pr__nfet_01v8[gm]
+@m.xm36.msky130_fd_pr__nfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm44.msky130_fd_pr__nfet_01v8[gm]
+@m.xm44.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm39.msky130_fd_pr__nfet_01v8[gm]
+@m.xm39.msky130_fd_pr__nfet_01v8[vth]
+@m.xm43.msky130_fd_pr__pfet_01v8[gm]
+@m.xm43.msky130_fd_pr__pfet_01v8[vth]
+@m.xm42.msky130_fd_pr__pfet_01v8[gm]
+@m.xm42.msky130_fd_pr__pfet_01v8[vth]
+@m.xm46.msky130_fd_pr__pfet_01v8[gm]
+@m.xm46.msky130_fd_pr__pfet_01v8[vth]
+@m.xm41.msky130_fd_pr__pfet_01v8[gm]
+@m.xm41.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm45.msky130_fd_pr__pfet_01v8[gm]
+@m.xm45.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__pfet_01v8[gm]
+@m.xm15.msky130_fd_pr__pfet_01v8[vth]
+@m.xm14.msky130_fd_pr__pfet_01v8[gm]
+@m.xm14.msky130_fd_pr__pfet_01v8[vth]
+@m.xm17.msky130_fd_pr__pfet_01v8[gm]
+@m.xm17.msky130_fd_pr__pfet_01v8[vth]
+@m.xm16.msky130_fd_pr__pfet_01v8[gm]
+@m.xm16.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__nfet_01v8[gm]
+@m.xm28.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__nfet_01v8[gm]
+@m.xm21.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__nfet_01v8[gm]
+@m.xm22.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__nfet_01v8[gm]
+@m.xm26.msky130_fd_pr__nfet_01v8[vth]
+@m.xm24.msky130_fd_pr__nfet_01v8[gm]
+@m.xm24.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]


.control

  save all
  * dc V1 0.0 2.0 0.005
  tran 0.05ns 6us
  remzerovec
  write tb_VTC.raw
  set appendwrite

.endc


"}
C {sky130_fd_pr/nfet_01v8.sym} 1590 -2280 0 0 {name=M1
W=32
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 680 -2280 0 1 {name=M2
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 230 -2420 0 1 {name=M5
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 380 -2570 0 0 {name=M7
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1610 -2040 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 1550 -2150 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 660 -2180 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 210 -2190 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 470 -2570 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1740 -2280 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 210 -2750 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 660 -3060 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 1610 -3060 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 1610 -2210 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 210 -2570 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 230 -2650 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1590 -2960 0 0 {name=M3
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 680 -2960 0 1 {name=M4
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 1770 -2200 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1270 -2100 0 0 {name=M8
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 930 -2100 0 1 {name=M9
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1290 -2000 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 910 -2000 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 910 -3240 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1290 -3240 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1270 -3140 0 0 {name=M10
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 930 -3140 0 1 {name=M11
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1610 -2550 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2030 -2150 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2010 -2050 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2010 -2780 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1990 -2680 0 0 {name=M13
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3740 -2880 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4120 -2880 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2780 0 0 {name=M14
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2780 0 1 {name=M15
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4100 -2510 0 0 {name=M16
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -2510 0 1 {name=M17
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -1860 0 0 {name=M18
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3740 -1760 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4140 -2080 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1860 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4100 -1730 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4120 -1630 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2350 -2780 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2330 -2680 0 0 {name=M25
W=24
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -2060 0 1 {name=M27
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2370 -1860 0 1 {name=M28
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2350 -1760 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 2800 -2780 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2680 0 0 {name=M29
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2410 0 0 {name=M30
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -2060 0 0 {name=M31
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -1860 0 0 {name=M32
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2800 -1760 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 2780 -2280 0 0 {name=M33
W=12
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4430 -2710 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4430 -2630 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4430 -2420 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4430 -2300 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3060 -2190 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 1870 -2610 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3060 -2150 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3060 -1990 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3060 -1940 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 3890 -1860 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 2800 -2560 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 2690 -2560 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 2800 -1960 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 910 -2820 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 770 -2370 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 3720 -2070 0 0 {name=M22
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3410 -2420 0 1 {name=M23
W=24
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -1860 0 0 {name=M24
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3390 -1760 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3370 -2070 0 0 {name=M26
W=8
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3390 -2520 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 2590 -2410 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1780 -2790 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 1780 -2910 0 1 {name=l28 lab=VDD}
C {devices/gnd.sym} 5630 -1890 0 0 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5470 -2040 0 1 {name=M38
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5810 -2040 0 0 {name=M39
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2420 0 1 {name=M40
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2420 0 0 {name=M41
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5850 -2280 0 1 {name=M42
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5430 -2280 0 0 {name=M43
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 7390 -900 0 0 {name=V2 value="pwl(0 0.17 2us 0.17 2us 0.169 4us 0.169 4us 0.171)" savecurrent=false
* 0.001 1.44 * 1.24 
* 1.34 1.25 "sin(1.0 0.001 200k)" }
C {devices/gnd.sym} 7390 -870 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 5940 -2420 0 1 {name=p25 lab=V_CTRL_VTC}
C {lab_pin.sym} 5830 -2180 0 1 {name=p28 lab=AMP_OUT}
C {lab_pin.sym} 5450 -2180 0 0 {name=p29 lab=AMP_MIR}
C {devices/ngspice_get_value.sym} 5470 -2010 2 1 {name=r7 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2010 2 0 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2250 2 1 {name=r11 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2250 2 0 {name=r12 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5470 -2380 2 1 {name=r13 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5810 -2380 2 0 {name=r14 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2650 2 0 {name=r22 node=v(@m.xm29.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2380 2 0 {name=r23 node=v(@m.xm30.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2250 2 0 {name=r24 node=v(@m.xm33.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -2030 2 0 {name=r25 node=v(@m.xm31.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2790 -1830 2 0 {name=r26 node=v(@m.xm32.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/res_high_po_0p35.sym} 1610 -2150 0 0 {name=R1
L=8
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/ngspice_get_value.sym} 4110 -2750 2 0 {name=r27 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2750 2 1 {name=r28 node=v(@m.xm15.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -1830 2 1 {name=r30 node=v(@m.xm28.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2360 -2030 2 1 {name=r29 node=v(@m.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1700 2 0 {name=r31 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -1830 2 0 {name=r32 node=v(@m.xm20.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4130 -2050 2 1 {name=r33 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4110 -2470 2 0 {name=r34 node=v(@m.xm16.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3750 -2470 2 1 {name=r35 node=v(@m.xm17.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -1830 2 0 {name=r36 node=v(@m.xm18.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3720 -2040 2 0 {name=r37 node=v(@m.xm22.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -1830 2 0 {name=r38 node=v(@m.xm24.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3370 -2040 2 0 {name=r39 node=v(@m.xm26.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 4120 -1980 2 1 {name=p35 sig_type=std_logic lab=Vncas_btw}
C {sky130_fd_pr/nfet_01v8.sym} 6100 -2040 0 0 {name=M34
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6400 -2040 0 0 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6400 -2280 0 0 {name=M36
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6440 -2250 2 1 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6110 -2010 2 0 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6410 -2010 2 0 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6420 -2400 0 0 {name=l33 lab=VDD}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5140 -2170 0 0 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=53 spiceprefix=X}
C {devices/gnd.sym} 5140 -2050 0 0 {name=l30 lab=GND}
C {devices/ngspice_get_value.sym} 4890 -2140 2 0 {name=r5 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 6580 -2110 2 0 {name=p19 sig_type=std_logic lab=S_RST}
C {sky130_fd_pr/pfet_01v8.sym} 4970 -2430 0 0 {name=M44
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 4980 -2400 2 0 {name=r6 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 4810 -2430 0 0 {name=p26 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 7350 -2110 0 1 {name=p27 lab=CLK_SWCAP}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -2630 0 0 {name=M49
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5630 -2600 2 0 {name=r18 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5460 -2630 0 0 {name=p30 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 5320 -2420 0 0 {name=p15 sig_type=std_logic lab=VIN_P}
C {lab_pin.sym} 7390 -980 0 1 {name=p22 lab=V_CTRL_VTC}
C {lab_wire.sym} 6120 -2170 0 0 {name=p23 sig_type=std_logic lab=PULL_DOWN}
C {devices/vdd.sym} 5640 -3200 0 0 {name=l36 lab=VDD}
C {lab_wire.sym} 5560 -2520 0 0 {name=p24 sig_type=std_logic lab=Vp}
C {lab_wire.sym} 7050 -2380 0 0 {name=p32 sig_type=std_logic lab=S_B}
C {lab_wire.sym} 7050 -2090 2 1 {name=p33 sig_type=std_logic lab=R_B}
C {lab_wire.sym} 6850 -2070 2 1 {name=p34 sig_type=std_logic lab=R}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -2780 0 0 {name=M45
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -2930 0 0 {name=M46
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4990 -3150 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4970 -2580 0 0 {name=M47
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4970 -2730 0 0 {name=M48
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5620 -3080 0 0 {name=M50
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4970 -2880 0 0 {name=M51
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4970 -3030 0 0 {name=M53
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -2630 0 0 {name=M52
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6110 -2600 2 0 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 5940 -2630 0 0 {name=p31 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6120 -3800 0 0 {name=l34 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -2780 0 0 {name=M54
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -2930 0 0 {name=M55
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -3080 0 0 {name=M56
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -3680 0 0 {name=M57
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -3230 0 0 {name=M58
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -3380 0 0 {name=M59
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6100 -3530 0 0 {name=M60
W=24
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ammeter.sym} 5140 -2270 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 4880 -2170 0 0 {name=M37
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4990 -2170 0 0 {name=l32 lab=GND}
C {sky130_stdcells/nand2_1.sym} 6950 -2380 0 0 {name=x1 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nand2_1.sym} 6950 -2090 0 0 {name=x2 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nand2_1.sym} 7140 -2360 0 0 {name=x3 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/nand2_1.sym} 7140 -2110 0 0 {name=x4 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 6790 -2070 0 0 {name=x5 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
