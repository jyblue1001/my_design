v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 9820 -3930 10080 -3740 {flags=graph

y2=3.2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.076















color=7
node=err_amp_vin}
B 2 9820 -3690 10080 -3500 {flags=graph

y2=3.2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.077
















color="7 6"
node="err_amp_vin
err_amp_ref"}
B 2 8510 -4620 8770 -4430 {flags=graph

y2=2.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1


















color="7 6"
node="err_amp_out
err_amp_amp_mir"}
B 2 7760 -4230 8020 -4040 {flags=graph

y2=2.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.17


















color=7
node=err_amp_out}
B 2 9820 -4330 10080 -4140 {flags=graph

y2=8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.29















color=7
node=v_converter_out}
B 2 6130 -3740 6390 -3550 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-1.5e-05






















color=6
node=sw_in}
B 2 12030 -2650 12290 -2460 {flags=graph

y2=41
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05

divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-17















color=7
node=v_converter_out
x2=0.0019370213}
B 2 7000 -3740 7260 -3550 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.045






















color=6
node=v_sawtooth}
B 2 6580 -3740 6840 -3550 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.00076























color=7
node=pmw_pull_down}
B 2 6580 -3520 6840 -3330 {flags=graph

y2=41
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-17















color=7
node=v_converter_out}
B 2 12030 -2410 12290 -2220 {flags=graph

y2=36
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.62

















color=6
node=v_diode}
B 2 12320 -2650 12580 -2460 {flags=graph

y2=2.0159716
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.17183753























color=7
node=pmw_pull_down}
B 2 9820 -4540 10080 -4350 {flags=graph

y2=2.0159716
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.17183753























color=7
node=pmw_pull_down}
B 2 12320 -2410 12580 -2220 {flags=graph

y2=68
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-48


















color=7
node=i(@s2[i])}
B 2 12030 -2190 12290 -2000 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0049


















color="7 6"
node="pmw_pull_down
sw1_inv"}
B 2 9020 -3900 9280 -3710 {flags=graph

y2=4.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.7021325e-05
x2=0.0019370213
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=1.8e-05
















color="6 7"
node="i(@m.xm37.msky130_fd_pr__nfet_01v8[id])
i(@m.xm44.msky130_fd_pr__nfet_01v8[id])"}
T {r=7769} 2230 -2880 0 0 0.4 0.4 {}
N 7230 -3920 7530 -3920 {lab=PMW_AMP_MIR}
N 7570 -4400 7570 -4330 {lab=PMW_Vp}
N 7190 -4400 7190 -4330 {lab=PMW_Vp}
N 7570 -4270 7570 -4190 {lab=PMW_VD1}
N 7190 -4270 7190 -4190 {lab=PMW_VD2}
N 7190 -4130 7190 -3950 {lab=PMW_AMP_OUT}
N 7570 -4130 7570 -3950 {lab=PMW_AMP_MIR}
N 7190 -3820 7570 -3820 {lab=GND}
N 7390 -3820 7390 -3790 {lab=GND}
N 7610 -4300 7670 -4300 {lab=V_SAWTOOTH}
N 7080 -4300 7150 -4300 {lab=ERR_AMP_OUT}
N 6800 -2480 6800 -2430 {lab=ST_V_REF}
N 7390 -4000 7570 -4000 {lab=PMW_AMP_MIR}
N 7390 -4000 7390 -3920 {lab=PMW_AMP_MIR}
N 7640 -3920 7640 -3820 {lab=GND}
N 7570 -3820 7640 -3820 {lab=GND}
N 7570 -3920 7640 -3920 {lab=GND}
N 7120 -3920 7120 -3820 {lab=GND}
N 7120 -3820 7190 -3820 {lab=GND}
N 7120 -3920 7190 -3920 {lab=GND}
N 7640 -4160 7640 -3920 {lab=GND}
N 7120 -4160 7120 -3920 {lab=GND}
N 7190 -4160 7570 -4160 {lab=VDD}
N 7190 -4300 7570 -4300 {lab=VDD}
N 7340 -4300 7340 -4160 {lab=VDD}
N 7570 -3890 7570 -3820 {lab=GND}
N 7190 -3890 7190 -3820 {lab=GND}
N 6750 -3920 6750 -3820 {lab=GND}
N 6750 -3820 6790 -3820 {lab=GND}
N 6750 -3920 6790 -3920 {lab=GND}
N 6790 -3890 6790 -3820 {lab=GND}
N 7070 -4000 7070 -3920 {lab=PMW_AMP_OUT}
N 6830 -3920 7070 -3920 {lab=PMW_AMP_OUT}
N 6790 -4340 6790 -3950 {lab=PMW_PULL_DOWN}
N 7190 -4400 7570 -4400 {lab=PMW_Vp}
N 7380 -4480 7380 -4400 {lab=PMW_Vp}
N 7610 -4160 7640 -4160 {lab=GND}
N 7120 -4160 7150 -4160 {lab=GND}
N 6790 -3820 7120 -3820 {lab=GND}
N 7340 -4510 7380 -4510 {lab=VDD}
N 7420 -4510 7460 -4510 {lab=Vbias1}
N 7460 -4510 7560 -4510 {lab=Vbias1}
N 7670 -4300 7730 -4300 {lab=V_SAWTOOTH}
N 7340 -4510 7340 -4300 {lab=VDD}
N 7340 -4590 7380 -4590 {lab=VDD}
N 7380 -4630 7380 -4540 {lab=VDD}
N 7340 -4590 7340 -4510 {lab=VDD}
N 7070 -4000 7190 -4000 {lab=PMW_AMP_OUT}
N 5200 -4000 5200 -3980 {lab=VDD}
N 5200 -3920 5200 -3900 {lab=GND}
N 1180 -3430 1180 -2810 {lab=V_REF_MIR}
N 2130 -3430 2130 -2810 {lab=V_REF}
N 1180 -3560 1180 -3490 {lab=VDD}
N 2130 -3560 2130 -3490 {lab=VDD}
N 1180 -2750 1180 -2680 {lab=GND}
N 2130 -2750 2130 -2680 {lab=V_RES}
N 1180 -2870 1290 -2870 {lab=V_REF_MIR}
N 1290 -2870 1290 -2780 {lab=V_REF_MIR}
N 2130 -3460 2170 -3460 {lab=VDD}
N 2170 -3520 2170 -3460 {lab=VDD}
N 2130 -3520 2170 -3520 {lab=VDD}
N 1140 -3460 1180 -3460 {lab=VDD}
N 1140 -3520 1140 -3460 {lab=VDD}
N 1140 -3520 1180 -3520 {lab=VDD}
N 1140 -2720 1180 -2720 {lab=GND}
N 1140 -2780 1140 -2720 {lab=GND}
N 1140 -2780 1180 -2780 {lab=GND}
N 2130 -2780 2260 -2780 {lab=GND}
N 730 -3120 730 -2950 {lab=START_UP}
N 730 -3250 730 -3180 {lab=VDD}
N 690 -3150 730 -3150 {lab=VDD}
N 690 -3210 690 -3150 {lab=VDD}
N 690 -3210 730 -3210 {lab=VDD}
N 690 -2920 690 -2860 {lab=GND}
N 690 -2920 730 -2920 {lab=GND}
N 920 -3070 990 -3070 {lab=GND}
N 730 -3070 880 -3070 {lab=START_UP}
N 770 -3150 800 -3150 {lab=START_UP}
N 800 -3150 800 -3070 {lab=START_UP}
N 920 -3110 920 -3100 {lab=Vbiasp}
N 920 -3040 920 -3030 {lab=V_REF_MIR}
N 920 -3030 1180 -3030 {lab=V_REF_MIR}
N 2070 -2650 2110 -2650 {lab=GND}
N 2130 -2620 2130 -2540 {lab=GND}
N 770 -2920 1180 -2920 {lab=V_REF_MIR}
N 730 -2890 730 -2810 {lab=GND}
N 730 -2810 730 -2690 {lab=GND}
N 690 -2860 730 -2860 {lab=GND}
N 1430 -3610 1430 -2630 {lab=Vbiasp_MIR}
N 1810 -3610 1810 -2630 {lab=Vbiasp}
N 1470 -3640 1770 -3640 {lab=Vbiasp_MIR}
N 1430 -3740 1430 -3670 {lab=VDD}
N 1810 -3740 1810 -3670 {lab=VDD}
N 1430 -2570 1430 -2500 {lab=GND}
N 1810 -2570 1810 -2500 {lab=GND}
N 1810 -3640 1850 -3640 {lab=VDD}
N 1850 -3700 1850 -3640 {lab=VDD}
N 1810 -3700 1850 -3700 {lab=VDD}
N 1390 -3640 1430 -3640 {lab=VDD}
N 1390 -3700 1390 -3640 {lab=VDD}
N 1390 -3700 1430 -3700 {lab=VDD}
N 1390 -2540 1430 -2540 {lab=GND}
N 1390 -2600 1390 -2540 {lab=GND}
N 1390 -2600 1430 -2600 {lab=GND}
N 1810 -2540 1850 -2540 {lab=GND}
N 1850 -2600 1850 -2540 {lab=GND}
N 1810 -2600 1850 -2600 {lab=GND}
N 1610 -3640 1610 -3530 {lab=Vbiasp_MIR}
N 1430 -3530 1610 -3530 {lab=Vbiasp_MIR}
N 1220 -2780 1290 -2780 {lab=V_REF_MIR}
N 1290 -2780 1640 -2780 {lab=V_REF_MIR}
N 1640 -2780 1770 -2600 {lab=V_REF_MIR}
N 1470 -2600 1710 -2780 {lab=V_REF}
N 1710 -2780 2090 -2780 {lab=V_REF}
N 2010 -2870 2010 -2780 {lab=V_REF}
N 2010 -2870 2130 -2870 {lab=V_REF}
N 1220 -3460 1810 -3460 {lab=Vbiasp}
N 1810 -3460 2090 -3460 {lab=Vbiasp}
N 920 -3110 1810 -3110 {lab=Vbiasp}
N 2530 -2620 2530 -2550 {lab=GND}
N 2490 -2590 2530 -2590 {lab=GND}
N 2490 -2650 2490 -2590 {lab=GND}
N 2490 -2650 2530 -2650 {lab=GND}
N 2530 -3280 2530 -3210 {lab=VDD}
N 2530 -3180 2570 -3180 {lab=VDD}
N 2570 -3240 2570 -3180 {lab=VDD}
N 2530 -3240 2570 -3240 {lab=VDD}
N 2530 -3150 2530 -2680 {lab=Vbias3}
N 4300 -3280 4600 -3280 {lab=Vbias1}
N 4260 -3380 4260 -3310 {lab=VDD}
N 4640 -3380 4640 -3310 {lab=VDD}
N 4640 -3280 4680 -3280 {lab=VDD}
N 4680 -3340 4680 -3280 {lab=VDD}
N 4640 -3340 4680 -3340 {lab=VDD}
N 4220 -3280 4260 -3280 {lab=VDD}
N 4220 -3340 4220 -3280 {lab=VDD}
N 4220 -3340 4260 -3340 {lab=VDD}
N 4440 -3280 4440 -3170 {lab=Vbias1}
N 4260 -2830 4440 -2830 {lab=Vbias1}
N 4300 -3010 4600 -3010 {lab=Vbias2}
N 4260 -3110 4260 -3040 {lab=Vhigh}
N 4640 -3110 4640 -3040 {lab=#net1}
N 4640 -3010 4680 -3010 {lab=VDD}
N 4680 -3070 4680 -3010 {lab=VDD}
N 4220 -3010 4260 -3010 {lab=VDD}
N 4220 -3070 4220 -3010 {lab=VDD}
N 4260 -3250 4260 -3110 {lab=Vhigh}
N 4640 -3250 4640 -3110 {lab=#net1}
N 4440 -3170 4440 -2830 {lab=Vbias1}
N 4260 -2980 4260 -2760 {lab=Vbias1}
N 4640 -2980 4640 -2760 {lab=Vncas}
N 4160 -2920 4360 -2920 {lab=Vbias2}
N 4360 -3010 4360 -2920 {lab=Vbias2}
N 4260 -2330 4260 -2260 {lab=GND}
N 4260 -2300 4300 -2300 {lab=GND}
N 4300 -2360 4300 -2300 {lab=GND}
N 4260 -2360 4300 -2360 {lab=GND}
N 4260 -2450 4260 -2390 {lab=#net2}
N 4070 -2360 4220 -2360 {lab=Vbias4}
N 4640 -2550 4640 -2480 {lab=#net3}
N 4600 -2580 4600 -2520 {lab=GND}
N 4600 -2580 4640 -2580 {lab=GND}
N 4640 -2760 4640 -2610 {lab=Vncas}
N 4640 -2800 4950 -2800 {lab=Vncas}
N 4680 -2580 4770 -2580 {lab=Vncas}
N 4640 -2330 4640 -2260 {lab=#net4}
N 4680 -2360 4680 -2300 {lab=GND}
N 4640 -2360 4680 -2360 {lab=GND}
N 4640 -2480 4640 -2390 {lab=#net3}
N 4640 -2200 4640 -2130 {lab=GND}
N 4640 -2170 4680 -2170 {lab=GND}
N 4680 -2230 4680 -2170 {lab=GND}
N 4640 -2230 4680 -2230 {lab=GND}
N 4510 -2230 4600 -2230 {lab=#net3}
N 4600 -2520 4680 -2520 {lab=GND}
N 4680 -2520 4680 -2360 {lab=GND}
N 4680 -2300 4680 -2230 {lab=GND}
N 4510 -2440 4510 -2230 {lab=#net3}
N 4510 -2440 4640 -2440 {lab=#net3}
N 4220 -3280 4220 -3070 {lab=VDD}
N 4680 -3280 4680 -3070 {lab=VDD}
N 2870 -3280 2870 -3210 {lab=VDD}
N 2870 -3180 2910 -3180 {lab=VDD}
N 2910 -3240 2910 -3180 {lab=VDD}
N 2870 -3240 2910 -3240 {lab=VDD}
N 2870 -3010 2870 -2940 {lab=Vbias4}
N 2870 -3150 2870 -3010 {lab=Vbias4}
N 2870 -2880 2870 -2660 {lab=Vbias4}
N 2830 -2560 2830 -2500 {lab=GND}
N 2870 -2660 2870 -2590 {lab=Vbias4}
N 2830 -2560 2870 -2560 {lab=GND}
N 2870 -2530 2870 -2460 {lab=Vlow}
N 4440 -3210 4950 -3210 {lab=Vbias1}
N 2720 -3180 2720 -3110 {lab=Vbiasp}
N 2720 -3180 2830 -3180 {lab=Vbiasp}
N 2830 -2360 2830 -2300 {lab=GND}
N 2870 -2460 2870 -2390 {lab=Vlow}
N 2830 -2360 2870 -2360 {lab=GND}
N 2870 -2330 2870 -2260 {lab=GND}
N 2830 -2300 2870 -2300 {lab=GND}
N 2910 -2360 2990 -2360 {lab=Vbias4}
N 2990 -2720 2990 -2360 {lab=Vbias4}
N 2870 -2720 2990 -2720 {lab=Vbias4}
N 4360 -2920 4950 -2920 {lab=Vbias2}
N 4770 -2800 4770 -2580 {lab=Vncas}
N 2830 -2500 2830 -2360 {lab=GND}
N 3320 -3280 3320 -3210 {lab=VDD}
N 3320 -3180 3360 -3180 {lab=VDD}
N 3360 -3240 3360 -3180 {lab=VDD}
N 3320 -3240 3360 -3240 {lab=VDD}
N 3320 -3010 3320 -2940 {lab=Vds2}
N 3320 -2910 3360 -2910 {lab=VDD}
N 3360 -2970 3360 -2910 {lab=VDD}
N 3320 -3150 3320 -3010 {lab=Vds2}
N 3360 -2560 3360 -2500 {lab=GND}
N 3320 -2660 3320 -2590 {lab=Vpcas}
N 3360 -3180 3360 -2970 {lab=VDD}
N 3320 -2560 3360 -2560 {lab=GND}
N 3320 -2530 3320 -2460 {lab=Vds3}
N 3210 -3180 3210 -3110 {lab=Vgs2}
N 3210 -3180 3280 -3180 {lab=Vgs2}
N 3360 -2360 3360 -2300 {lab=GND}
N 3320 -2460 3320 -2390 {lab=Vds3}
N 3320 -2360 3360 -2360 {lab=GND}
N 3320 -2330 3320 -2260 {lab=GND}
N 3320 -2300 3360 -2300 {lab=GND}
N 3200 -2360 3280 -2360 {lab=Vbias4}
N 3110 -2910 3280 -2910 {lab=Vbias2}
N 3360 -2500 3360 -2360 {lab=GND}
N 2990 -2360 3200 -2360 {lab=Vbias4}
N 2910 -2560 3280 -2560 {lab=Vbias3}
N 3110 -2650 3110 -2560 {lab=Vbias3}
N 3320 -2780 3360 -2780 {lab=VDD}
N 3360 -2840 3360 -2780 {lab=VDD}
N 3210 -2780 3210 -2690 {lab=Vpcas}
N 3210 -2780 3280 -2780 {lab=Vpcas}
N 3360 -2910 3360 -2840 {lab=VDD}
N 3320 -2880 3320 -2810 {lab=Vgs2}
N 3210 -3110 3210 -2850 {lab=Vgs2}
N 3210 -2850 3320 -2850 {lab=Vgs2}
N 3320 -2750 3320 -2660 {lab=Vpcas}
N 3210 -2690 3320 -2690 {lab=Vpcas}
N 3320 -2690 3580 -2690 {lab=Vpcas}
N 4410 -2360 4600 -2360 {lab=Vbias3}
N 2390 -3110 2420 -3110 {lab=Vbiasp}
N 3110 -2650 3580 -2650 {lab=Vbias3}
N 2870 -2490 3580 -2490 {lab=Vlow}
N 2990 -2440 3580 -2440 {lab=Vbias4}
N 4260 -3130 4950 -3130 {lab=Vhigh}
N 1980 -3460 1980 -3370 {lab=Vbiasp}
N 2410 -3180 2490 -3180 {lab=Vbiasp}
N 1980 -3180 2410 -3180 {lab=Vbiasp}
N 1980 -3370 1980 -3180 {lab=Vbiasp}
N 2870 -2940 2870 -2880 {lab=Vbias4}
N 2570 -2650 2780 -2650 {lab=Vbias3}
N 2640 -2760 2640 -2650 {lab=Vbias3}
N 2530 -2760 2640 -2760 {lab=Vbias3}
N 2420 -3110 2720 -3110 {lab=Vbiasp}
N 2390 -3180 2390 -3110 {lab=Vbiasp}
N 2780 -2650 3110 -2650 {lab=Vbias3}
N 4260 -2540 4260 -2450 {lab=#net2}
N 4260 -2570 4300 -2570 {lab=GND}
N 4260 -2760 4260 -2600 {lab=Vbias1}
N 4300 -2570 4300 -2360 {lab=GND}
N 4070 -2570 4220 -2570 {lab=Vbias3}
N 3870 -2920 3910 -2920 {lab=VDD}
N 3910 -2890 3910 -2760 {lab=Vbias2}
N 3910 -2330 3910 -2260 {lab=GND}
N 3910 -2300 3950 -2300 {lab=GND}
N 3950 -2360 3950 -2300 {lab=GND}
N 3910 -2360 3950 -2360 {lab=GND}
N 3910 -2450 3910 -2390 {lab=#net5}
N 3720 -2360 3870 -2360 {lab=Vbias4}
N 3910 -2540 3910 -2450 {lab=#net5}
N 3910 -2570 3950 -2570 {lab=GND}
N 3910 -2760 3910 -2600 {lab=Vbias2}
N 3950 -2570 3950 -2360 {lab=GND}
N 3720 -2570 3870 -2570 {lab=Vbias3}
N 3910 -3020 3910 -2950 {lab=VDD}
N 3870 -2980 3870 -2920 {lab=VDD}
N 3870 -2980 3910 -2980 {lab=VDD}
N 3950 -2920 4160 -2920 {lab=Vbias2}
N 4000 -2920 4000 -2830 {lab=Vbias2}
N 3910 -2830 4000 -2830 {lab=Vbias2}
N 3580 -2650 3720 -2650 {lab=Vbias3}
N 3720 -2650 3720 -2570 {lab=Vbias3}
N 3580 -2440 3720 -2440 {lab=Vbias4}
N 3720 -2440 3720 -2360 {lab=Vbias4}
N 4070 -2650 4070 -2570 {lab=Vbias3}
N 4070 -2440 4070 -2360 {lab=Vbias4}
N 3720 -2440 4070 -2440 {lab=Vbias4}
N 3720 -2650 4070 -2650 {lab=Vbias3}
N 4070 -2650 4410 -2650 {lab=Vbias3}
N 4410 -2650 4410 -2360 {lab=Vbias3}
N 2300 -3410 2300 -3320 {lab=VDD}
N 2300 -3260 2300 -3180 {lab=Vbiasp}
N 9420 -3690 9420 -3620 {lab=GND}
N 9380 -3660 9420 -3660 {lab=GND}
N 9380 -3720 9380 -3660 {lab=GND}
N 9380 -3720 9420 -3720 {lab=GND}
N 9380 -3860 9380 -3800 {lab=GND}
N 9380 -3860 9420 -3860 {lab=GND}
N 9420 -3830 9420 -3750 {lab=ERR_V_tail_btw}
N 9380 -3800 9380 -3720 {lab=GND}
N 9260 -4200 9560 -4200 {lab=ERR_AMP_Vb1}
N 9260 -4580 9560 -4580 {lab=ERR_AMP_AMP_MIR}
N 9600 -4680 9600 -4610 {lab=VDD}
N 9220 -4680 9220 -4610 {lab=VDD}
N 9180 -4580 9220 -4580 {lab=VDD}
N 9180 -4640 9180 -4580 {lab=VDD}
N 9180 -4640 9220 -4640 {lab=VDD}
N 9600 -4580 9640 -4580 {lab=VDD}
N 9640 -4640 9640 -4580 {lab=VDD}
N 9600 -4640 9640 -4640 {lab=VDD}
N 9260 -4440 9560 -4440 {lab=Vbias2}
N 9180 -4440 9220 -4440 {lab=VDD}
N 9600 -4440 9640 -4440 {lab=VDD}
N 9640 -4580 9640 -4440 {lab=VDD}
N 9180 -4580 9180 -4440 {lab=VDD}
N 9600 -4170 9600 -4070 {lab=ERR_AMP_Vd1}
N 9220 -4170 9220 -4070 {lab=ERR_AMP_Vd2}
N 9600 -4550 9600 -4470 {lab=ERR_AMP_Vd3}
N 9220 -4550 9220 -4470 {lab=ERR_AMP_Vd4}
N 9600 -4410 9600 -4230 {lab=ERR_AMP_AMP_MIR}
N 9600 -4200 9680 -4200 {lab=GND}
N 9140 -4200 9220 -4200 {lab=GND}
N 9600 -4010 9600 -3950 {lab=ERR_AMP_Vp}
N 9220 -3950 9600 -3950 {lab=ERR_AMP_Vp}
N 9220 -4010 9220 -3950 {lab=ERR_AMP_Vp}
N 9420 -3950 9420 -3890 {lab=ERR_AMP_Vp}
N 9380 -4040 9380 -3860 {lab=GND}
N 9220 -4040 9380 -4040 {lab=GND}
N 9380 -4040 9600 -4040 {lab=GND}
N 9420 -4080 9420 -3950 {lab=ERR_AMP_Vp}
N 9380 -4110 9420 -4110 {lab=GND}
N 9380 -4110 9380 -4040 {lab=GND}
N 9420 -4200 9420 -4140 {lab=ERR_AMP_Vb1}
N 9460 -4110 9490 -4110 {lab=ERR_AMP_Vb1}
N 9490 -4160 9490 -4110 {lab=ERR_AMP_Vb1}
N 9420 -4160 9490 -4160 {lab=ERR_AMP_Vb1}
N 9520 -4260 9600 -4260 {lab=ERR_AMP_AMP_MIR}
N 9520 -4580 9520 -4260 {lab=ERR_AMP_AMP_MIR}
N 9310 -4650 9350 -4650 {lab=VDD}
N 9310 -4340 9350 -4340 {lab=VDD}
N 9350 -4620 9350 -4370 {lab=#net6}
N 9310 -4650 9310 -4340 {lab=VDD}
N 9350 -4310 9350 -4200 {lab=ERR_AMP_Vb1}
N 9350 -4750 9350 -4680 {lab=VDD}
N 9310 -4710 9310 -4650 {lab=VDD}
N 9310 -4710 9350 -4710 {lab=VDD}
N 9390 -4340 9430 -4340 {lab=Vbias2}
N 9430 -4440 9430 -4340 {lab=Vbias2}
N 9390 -4650 9470 -4650 {lab=Vbias1}
N 9460 -3860 9590 -3860 {lab=Vbias3}
N 9460 -3720 9590 -3720 {lab=Vbias4}
N 8950 -4040 9180 -4040 {lab=ERR_AMP_VIN}
N 9640 -4040 9930 -4040 {lab=ERR_AMP_REF}
N 10320 -4410 10320 -4260 {lab=V_CONVERTER_OUT}
N 10320 -4410 10470 -4410 {lab=V_CONVERTER_OUT}
N 10470 -4410 10470 -4340 {lab=V_CONVERTER_OUT}
N 10320 -4040 10470 -4040 {lab=ERR_AMP_VIN}
N 10470 -4090 10470 -4040 {lab=ERR_AMP_VIN}
N 10390 -3920 10390 -3830 {lab=GND}
N 10390 -4040 10390 -3980 {lab=ERR_AMP_VIN}
N 10390 -4610 10390 -4410 {lab=V_CONVERTER_OUT}
N 8570 -4010 8630 -4010 {lab=#net7}
N 8570 -4080 8570 -4010 {lab=#net7}
N 8570 -4080 8590 -4080 {lab=#net7}
N 8830 -4080 8850 -4080 {lab=ERR_AMP_VIN}
N 8850 -4080 8850 -4010 {lab=ERR_AMP_VIN}
N 10190 -3470 10190 -3420 {lab=ERR_AMP_REF}
N 7180 -2070 7480 -2070 {lab=ST_AMP_MIR}
N 7520 -2550 7520 -2480 {lab=ST_Vp}
N 7140 -2550 7140 -2480 {lab=ST_Vp}
N 7520 -2420 7520 -2340 {lab=ST_VD1}
N 7140 -2420 7140 -2340 {lab=ST_VD2}
N 7140 -2280 7140 -2100 {lab=ST_AMP_OUT}
N 7520 -2280 7520 -2100 {lab=ST_AMP_MIR}
N 7140 -1970 7520 -1970 {lab=GND}
N 7340 -1970 7340 -1940 {lab=GND}
N 7560 -2450 7620 -2450 {lab=V_SAWTOOTH}
N 7030 -2450 7100 -2450 {lab=ST_V_REF}
N 7340 -2150 7520 -2150 {lab=ST_AMP_MIR}
N 7340 -2150 7340 -2070 {lab=ST_AMP_MIR}
N 7590 -2070 7590 -1970 {lab=GND}
N 7520 -1970 7590 -1970 {lab=GND}
N 7520 -2070 7590 -2070 {lab=GND}
N 7070 -2070 7070 -1970 {lab=GND}
N 7070 -1970 7140 -1970 {lab=GND}
N 7070 -2070 7140 -2070 {lab=GND}
N 7590 -2310 7590 -2070 {lab=GND}
N 7070 -2310 7070 -2070 {lab=GND}
N 7140 -2310 7520 -2310 {lab=VDD}
N 7140 -2450 7520 -2450 {lab=VDD}
N 7290 -2450 7290 -2310 {lab=VDD}
N 7520 -2040 7520 -1970 {lab=GND}
N 7140 -2040 7140 -1970 {lab=GND}
N 6620 -2070 6620 -1970 {lab=GND}
N 6620 -1970 6660 -1970 {lab=GND}
N 6620 -2070 6660 -2070 {lab=GND}
N 6660 -2040 6660 -1970 {lab=GND}
N 5520 -2070 5520 -1970 {lab=GND}
N 5520 -1970 5560 -1970 {lab=GND}
N 5520 -2070 5560 -2070 {lab=GND}
N 5560 -2040 5560 -1970 {lab=GND}
N 7020 -2150 7020 -2070 {lab=ST_AMP_OUT}
N 6700 -2070 7020 -2070 {lab=ST_AMP_OUT}
N 6660 -2630 6660 -2100 {lab=ST_PULL_DOWN}
N 5650 -2150 5650 -2070 {lab=ST_PULL_DOWN2}
N 5600 -2070 5650 -2070 {lab=ST_PULL_DOWN2}
N 5560 -2280 5560 -2100 {lab=S_RST}
N 5650 -2310 5650 -2150 {lab=ST_PULL_DOWN2}
N 5600 -2310 5650 -2310 {lab=ST_PULL_DOWN2}
N 5650 -2200 5980 -2200 {lab=ST_PULL_DOWN2}
N 5520 -2380 5520 -2310 {lab=VDD}
N 5520 -2310 5560 -2310 {lab=VDD}
N 5560 -2380 5560 -2340 {lab=VDD}
N 5520 -2380 5560 -2380 {lab=VDD}
N 5560 -2430 5560 -2380 {lab=VDD}
N 7140 -2550 7520 -2550 {lab=ST_Vp}
N 7330 -2630 7330 -2550 {lab=ST_Vp}
N 5490 -2200 5560 -2200 {lab=S_RST}
N 7560 -2310 7590 -2310 {lab=GND}
N 7070 -2310 7100 -2310 {lab=GND}
N 6660 -1970 7070 -1970 {lab=GND}
N 5560 -1970 6620 -1970 {lab=GND}
N 7290 -2660 7330 -2660 {lab=VDD}
N 7370 -2660 7410 -2660 {lab=Vbias1}
N 7410 -2660 7510 -2660 {lab=Vbias1}
N 7620 -2450 7680 -2450 {lab=V_SAWTOOTH}
N 7290 -2660 7290 -2450 {lab=VDD}
N 7290 -2740 7330 -2740 {lab=VDD}
N 7330 -2780 7330 -2690 {lab=VDD}
N 7290 -2740 7290 -2660 {lab=VDD}
N 6620 -2660 6660 -2660 {lab=VDD}
N 6700 -2660 6740 -2660 {lab=Vbias1}
N 6740 -2660 6790 -2660 {lab=Vbias1}
N 6620 -2740 6620 -2660 {lab=VDD}
N 6660 -2780 6660 -2690 {lab=#net8}
N 7020 -2150 7140 -2150 {lab=ST_AMP_OUT}
N 5470 -2200 5490 -2200 {lab=S_RST}
N 7860 -2260 7860 -2160 {lab=GND}
N 8060 -2220 8100 -2220 {lab=GND}
N 8100 -2260 8100 -2220 {lab=GND}
N 7860 -2220 8060 -2220 {lab=GND}
N 7860 -2450 8100 -2450 {lab=V_SAWTOOTH}
N 8100 -2450 8100 -2320 {lab=V_SAWTOOTH}
N 7800 -2450 7860 -2450 {lab=V_SAWTOOTH}
N 8010 -2290 8100 -2290 {lab=GND}
N 7860 -2360 7860 -2320 {lab=#net9}
N 7860 -2450 7860 -2420 {lab=V_SAWTOOTH}
N 7680 -2450 7800 -2450 {lab=V_SAWTOOTH}
N 5470 -2200 5470 -1800 {lab=S_RST}
N 5470 -1800 8070 -1800 {lab=S_RST}
N 8230 -2290 8230 -1800 {lab=S_RST}
N 8140 -2290 8230 -2290 {lab=S_RST}
N 7980 -2530 7980 -2450 {lab=V_SAWTOOTH}
N 7940 -2560 7980 -2560 {lab=VDD}
N 8020 -2560 8060 -2560 {lab=Vbias1}
N 8060 -2560 8160 -2560 {lab=Vbias1}
N 7760 -2870 7760 -2450 {lab=V_SAWTOOTH}
N 7980 -2650 7980 -2590 {lab=#net10}
N 7940 -2680 7980 -2680 {lab=VDD}
N 7980 -2800 7980 -2710 {lab=#net11}
N 7940 -2680 7940 -2560 {lab=VDD}
N 7940 -3010 7980 -3010 {lab=VDD}
N 7980 -3130 7980 -3040 {lab=VDD}
N 7940 -2830 7940 -2680 {lab=VDD}
N 7940 -3130 7940 -3010 {lab=VDD}
N 7940 -3130 7980 -3130 {lab=VDD}
N 7980 -3160 7980 -3130 {lab=VDD}
N 8070 -2680 8070 -2560 {lab=Vbias1}
N 8020 -2680 8070 -2680 {lab=Vbias1}
N 8070 -2830 8070 -2680 {lab=Vbias1}
N 8020 -3010 8070 -3010 {lab=Vbias1}
N 7940 -2860 7980 -2860 {lab=VDD}
N 7980 -2980 7980 -2890 {lab=#net12}
N 7940 -3010 7940 -2860 {lab=VDD}
N 8020 -2860 8070 -2860 {lab=Vbias1}
N 8070 -3010 8070 -2860 {lab=Vbias1}
N 7940 -2860 7940 -2830 {lab=VDD}
N 7980 -2830 7980 -2800 {lab=#net11}
N 8070 -2860 8070 -2830 {lab=Vbias1}
N 8070 -1800 8230 -1800 {lab=S_RST}
N 6060 -2300 6060 -2140 {lab=ST_PULL_DOWN2}
N 6120 -2300 6120 -2140 {lab=#net13}
N 6090 -2100 6090 -2070 {lab=VDD}
N 6090 -2370 6090 -2340 {lab=GND}
N 6090 -2160 6090 -2140 {lab=GND}
N 6090 -2160 6140 -2160 {lab=GND}
N 6140 -2360 6140 -2160 {lab=GND}
N 6090 -2360 6140 -2360 {lab=GND}
N 6090 -2300 6090 -2280 {lab=VDD}
N 6040 -2280 6090 -2280 {lab=VDD}
N 6040 -2280 6040 -2090 {lab=VDD}
N 6040 -2090 6090 -2090 {lab=VDD}
N 6210 -2300 6210 -2140 {lab=#net13}
N 6270 -2300 6270 -2140 {lab=#net14}
N 6240 -2100 6240 -2070 {lab=VDD}
N 6240 -2370 6240 -2340 {lab=GND}
N 6240 -2160 6240 -2140 {lab=GND}
N 6240 -2160 6290 -2160 {lab=GND}
N 6290 -2360 6290 -2160 {lab=GND}
N 6240 -2360 6290 -2360 {lab=GND}
N 6240 -2300 6240 -2280 {lab=VDD}
N 6190 -2280 6240 -2280 {lab=VDD}
N 6190 -2280 6190 -2090 {lab=VDD}
N 6190 -2090 6240 -2090 {lab=VDD}
N 6120 -2200 6210 -2200 {lab=#net13}
N 6360 -2300 6360 -2140 {lab=#net14}
N 6420 -2300 6420 -2140 {lab=#net15}
N 6390 -2100 6390 -2070 {lab=VDD}
N 6390 -2370 6390 -2340 {lab=GND}
N 6390 -2160 6390 -2140 {lab=GND}
N 6390 -2160 6440 -2160 {lab=GND}
N 6440 -2360 6440 -2160 {lab=GND}
N 6390 -2360 6440 -2360 {lab=GND}
N 6390 -2300 6390 -2280 {lab=VDD}
N 6340 -2280 6390 -2280 {lab=VDD}
N 6340 -2280 6340 -2090 {lab=VDD}
N 6340 -2090 6390 -2090 {lab=VDD}
N 6270 -2200 6360 -2200 {lab=#net14}
N 5980 -2200 6000 -2200 {lab=ST_PULL_DOWN2}
N 6000 -2200 6060 -2200 {lab=ST_PULL_DOWN2}
N 6620 -2810 6660 -2810 {lab=VDD}
N 6700 -2810 6740 -2810 {lab=Vbias1}
N 6620 -2890 6620 -2810 {lab=VDD}
N 6660 -2930 6660 -2840 {lab=#net16}
N 6620 -2960 6660 -2960 {lab=VDD}
N 6700 -2960 6740 -2960 {lab=Vbias1}
N 6620 -3040 6660 -3040 {lab=VDD}
N 6620 -3040 6620 -2960 {lab=VDD}
N 6660 -3080 6660 -2990 {lab=VDD}
N 6620 -2960 6620 -2890 {lab=VDD}
N 6740 -2960 6740 -2810 {lab=Vbias1}
N 6620 -2810 6620 -2740 {lab=VDD}
N 6740 -2810 6740 -2660 {lab=Vbias1}
N 6560 -2200 6660 -2200 {lab=ST_PULL_DOWN}
N 6420 -2200 6500 -2200 {lab=#net15}
N 6870 -4370 6920 -4370 {lab=Vbias1}
N 6750 -4370 6790 -4370 {lab=VDD}
N 6830 -4370 6870 -4370 {lab=Vbias1}
N 6750 -4450 6750 -4370 {lab=VDD}
N 6790 -4490 6790 -4400 {lab=#net17}
N 6750 -4520 6790 -4520 {lab=VDD}
N 6830 -4520 6870 -4520 {lab=Vbias1}
N 6750 -4600 6750 -4520 {lab=VDD}
N 6790 -4640 6790 -4550 {lab=#net18}
N 6750 -4670 6790 -4670 {lab=VDD}
N 6830 -4670 6870 -4670 {lab=Vbias1}
N 6750 -4750 6790 -4750 {lab=VDD}
N 6750 -4750 6750 -4670 {lab=VDD}
N 6790 -4790 6790 -4700 {lab=VDD}
N 6750 -4670 6750 -4600 {lab=VDD}
N 6870 -4670 6870 -4520 {lab=Vbias1}
N 6750 -4520 6750 -4450 {lab=VDD}
N 6870 -4520 6870 -4370 {lab=Vbias1}
N 8850 -4040 8950 -4040 {lab=ERR_AMP_VIN}
N 8530 -4040 8570 -4040 {lab=#net7}
N 8530 -4130 8530 -4040 {lab=#net7}
N 9220 -4250 9220 -4230 {lab=#net19}
N 9220 -4410 9220 -4310 {lab=ERR_AMP_OUT}
N 8860 -4350 9220 -4350 {lab=ERR_AMP_OUT}
N 8440 -4350 8800 -4350 {lab=ERR_AMP_OUT}
N 8530 -4350 8530 -4190 {lab=ERR_AMP_OUT}
N 8740 -4080 8770 -4080 {lab=#net20}
N 8650 -4080 8680 -4080 {lab=INT_BTW}
N 8690 -4010 8740 -4010 {lab=#net21}
N 8800 -4010 8850 -4010 {lab=ERR_AMP_VIN}
N 8660 -4160 8660 -4080 {lab=INT_BTW}
N 10320 -4090 10320 -4040 {lab=ERR_AMP_VIN}
N 10320 -4200 10320 -4150 {lab=#net22}
N 10470 -4190 10470 -4150 {lab=#net23}
N 10470 -4280 10470 -4250 {lab=#net24}
N 8800 -4350 8860 -4350 {lab=ERR_AMP_OUT}
N 11310 -2780 11310 -2270 {lab=V_DIODE}
N 11310 -2970 11310 -2840 {lab=buck_vin}
N 10220 -2970 11310 -2970 {lab=buck_vin}
N 10220 -2970 10220 -2880 {lab=buck_vin}
N 11310 -2750 11490 -2750 {lab=V_DIODE}
N 11550 -2750 11740 -2750 {lab=V_CONVERTER_OUT}
N 11310 -2210 11310 -1630 {lab=GND}
N 11310 -1630 11740 -1630 {lab=GND}
N 11740 -1970 11740 -1630 {lab=GND}
N 11740 -2750 11890 -2750 {lab=V_CONVERTER_OUT}
N 11890 -2750 11890 -2270 {lab=V_CONVERTER_OUT}
N 11890 -2210 11890 -1630 {lab=GND}
N 11740 -1630 11890 -1630 {lab=GND}
N 11740 -2400 11740 -2030 {lab=#net25}
N 11740 -2750 11740 -2460 {lab=V_CONVERTER_OUT}
N 10220 -2880 10220 -2740 {lab=buck_vin}
N 10220 -2680 10220 -1630 {lab=GND}
N 10220 -1630 11310 -1630 {lab=GND}
N 11270 -2790 11270 -2770 {lab=GND}
N 10790 -2810 11270 -2810 {lab=PMW_PULL_DOWN}
N 10880 -2230 10960 -2230 {lab=PMW_PULL_DOWN}
N 10880 -2810 10880 -2230 {lab=PMW_PULL_DOWN}
N 6430 -3920 6430 -3820 {lab=GND}
N 6430 -3820 6470 -3820 {lab=GND}
N 6430 -3920 6470 -3920 {lab=GND}
N 6470 -3890 6470 -3820 {lab=GND}
N 6560 -4000 6560 -3920 {lab=PMW_PULL_DOWN}
N 6510 -3920 6560 -3920 {lab=PMW_PULL_DOWN}
N 6470 -4130 6470 -3950 {lab=SW_IN}
N 6560 -4160 6560 -4000 {lab=PMW_PULL_DOWN}
N 6510 -4160 6560 -4160 {lab=PMW_PULL_DOWN}
N 6430 -4230 6430 -4160 {lab=VDD}
N 6430 -4160 6470 -4160 {lab=VDD}
N 6470 -4230 6470 -4190 {lab=VDD}
N 6430 -4230 6470 -4230 {lab=VDD}
N 6470 -4280 6470 -4230 {lab=VDD}
N 6560 -4050 6790 -4050 {lab=PMW_PULL_DOWN}
N 6240 -4050 6470 -4050 {lab=SW_IN}
N 6470 -3820 6750 -3820 {lab=GND}
N 11270 -2220 11270 -2200 {lab=GND}
N 11000 -2180 11000 -2160 {lab=GND}
N 10960 -2190 10960 -2170 {lab=GND}
N 11000 -2240 11080 -2240 {lab=#net26}
N 11140 -2240 11270 -2240 {lab=SW1_INV}
C {devices/vsource.sym} 5200 -3950 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 5200 -3900 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 5200 -4000 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 5010 -4000 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 8690 -2860 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

.save
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm44.msky130_fd_pr__nfet_01v8[gm]
+@m.xm44.msky130_fd_pr__nfet_01v8[vth]



* .include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
* .model D1N914 D(Is=168.1E-21 N=1 Rs=.1 Ikf=1 Xti=3 Eg=1.11 Cjo=4p M=.3333 Vj=.75 Fc=.5 Bv=100 Ibv=100u Tt=11.54n)
.model D1N914 D(Is=533.1E-6 N=1.95 Rs=0.00141 Cjo=1.34n M=0.333 Bv=35 Ibv=50u Tt=1.44n)


.control
  * save v(sw_in) v(v_converter_out)
  save all
  tran 100ns 3ms
  remzerovec
  write tb_buck_converter_2.raw
  set appendwrite

.endc

"
}
C {devices/gnd.sym} 7390 -3800 0 1 {name=l29 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7550 -3920 0 0 {name=M38
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7210 -3920 0 1 {name=M39
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7170 -4300 0 0 {name=M40
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7590 -4300 0 1 {name=M41
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7170 -4160 0 0 {name=M42
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7590 -4160 0 1 {name=M43
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 6800 -2400 0 0 {name=V2 value=1.6 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 6800 -2370 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 7190 -4060 0 0 {name=p28 lab=PMW_AMP_OUT}
C {lab_pin.sym} 7570 -4060 0 1 {name=p29 lab=PMW_AMP_MIR}
C {devices/ngspice_get_value.sym} 7550 -3890 2 0 {name=r7 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7210 -3890 2 1 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7550 -4130 2 0 {name=r11 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7210 -4130 2 1 {name=r12 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7550 -4260 2 0 {name=r13 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7210 -4260 2 1 {name=r14 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 6810 -3920 0 1 {name=M34
W=2
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6800 -3890 2 1 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 7400 -4510 0 1 {name=M49
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7390 -4480 2 1 {name=r18 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7560 -4510 0 1 {name=p30 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 6800 -2480 0 1 {name=p22 lab=ST_V_REF}
C {devices/vdd.sym} 7380 -4630 0 1 {name=l36 lab=VDD}
C {lab_wire.sym} 7460 -4400 0 1 {name=p24 sig_type=std_logic lab=PMW_Vp}
C {lab_pin.sym} 7190 -4220 0 0 {name=p34 lab=PMW_VD2}
C {lab_pin.sym} 7570 -4220 0 1 {name=p36 lab=PMW_VD1}
C {lab_pin.sym} 7730 -4300 2 0 {name=p15 lab=V_SAWTOOTH}
C {lab_pin.sym} 7080 -4300 2 1 {name=p25 lab=ERR_AMP_OUT}
C {sky130_fd_pr/nfet_01v8.sym} 2110 -2780 0 0 {name=M1
W=16
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1200 -2780 0 1 {name=M2
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 -2920 0 1 {name=M5
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 900 -3070 0 0 {name=M7
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 -2540 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 2070 -2650 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 1180 -2680 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 730 -2690 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 990 -3070 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 2260 -2780 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 730 -3250 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 1180 -3560 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 2130 -3560 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 2130 -2710 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 730 -3070 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 750 -3150 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2110 -3460 0 0 {name=M3
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1200 -3460 0 1 {name=M4
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 2290 -2700 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -2600 0 0 {name=M8
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 -2600 0 1 {name=M9
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1810 -2500 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 1430 -2500 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 1430 -3740 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1810 -3740 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1790 -3640 0 0 {name=M10
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1450 -3640 0 1 {name=M11
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2130 -3050 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2550 -2650 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2550 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2530 -3280 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2510 -3180 0 0 {name=M13
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4260 -3380 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4640 -3380 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3280 0 0 {name=M14
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3280 0 1 {name=M15
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3010 0 0 {name=M16
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3010 0 1 {name=M17
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2360 0 0 {name=M18
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4260 -2260 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4660 -2580 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2360 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2230 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4640 -2130 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2870 -3280 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2850 -3180 0 0 {name=M25
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2560 0 1 {name=M27
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2360 0 1 {name=M28
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2870 -2260 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 3320 -3280 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -3180 0 0 {name=M29
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2910 0 0 {name=M30
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2560 0 0 {name=M31
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2360 0 0 {name=M32
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3320 -2260 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2780 0 0 {name=M33
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4950 -3210 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4950 -3130 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4950 -2920 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4950 -2800 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3580 -2690 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 2390 -3110 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3580 -2650 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3580 -2490 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3580 -2440 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 4410 -2360 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3320 -3060 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 3210 -3060 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 3320 -2460 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 1430 -3320 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 1290 -2870 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2570 0 0 {name=M22
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3930 -2920 0 1 {name=M23
W=12
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2360 0 0 {name=M24
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3910 -2260 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2570 0 0 {name=M26
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3910 -3020 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 3110 -2910 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 -3290 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 2300 -3410 0 1 {name=l28 lab=VDD}
C {sky130_fd_pr/res_high_po_0p35.sym} 2130 -2650 0 0 {name=R1
L=10
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -3720 0 1 {name=M37
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
value=1110}
C {devices/gnd.sym} 9420 -3620 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -3860 0 1 {name=M44
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
value=1110}
C {sky130_fd_pr/nfet_01v8.sym} 9620 -4040 0 1 {name=M45
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9200 -4040 0 0 {name=M46
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9580 -4200 0 0 {name=M47
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9240 -4200 0 1 {name=M48
W=12
L=0.3
nf=4 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9600 -4680 0 1 {name=l31 lab=VDD}
C {devices/vdd.sym} 9220 -4680 0 1 {name=l32 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 9240 -4580 0 1 {name=M50
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9580 -4580 0 0 {name=M51
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9240 -4440 0 1 {name=M53
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9580 -4440 0 0 {name=M54
W=12
L=0.3
nf=4
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9140 -4200 0 1 {name=l35 lab=GND}
C {devices/gnd.sym} 9680 -4200 0 0 {name=l37 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -4110 0 1 {name=M55
W=1
L=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9370 -4650 0 1 {name=M56
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9370 -4340 0 1 {name=M57
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9350 -4750 0 1 {name=l38 lab=VDD}
C {lab_wire.sym} 9470 -4650 0 1 {name=p27 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 9410 -4440 0 1 {name=p32 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 9590 -3860 2 0 {name=p33 sig_type=std_logic lab=Vbias3
value=1110}
C {lab_wire.sym} 9590 -3720 2 0 {name=p35 sig_type=std_logic lab=Vbias4
value=1110}
C {lab_pin.sym} 9600 -4340 0 1 {name=p38 lab=ERR_AMP_AMP_MIR}
C {lab_wire.sym} 9450 -3950 0 1 {name=p39 sig_type=std_logic lab=ERR_AMP_Vp}
C {lab_wire.sym} 9460 -4200 0 1 {name=p40 sig_type=std_logic lab=ERR_AMP_Vb1}
C {devices/ngspice_get_value.sym} 9440 -3680 2 1 {name=r5 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="
value=1110}
C {devices/ngspice_get_value.sym} 9440 -3820 2 1 {name=r6 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vth])
descr="vth="
value=1110}
C {devices/ngspice_get_value.sym} 9620 -4000 2 1 {name=r15 node=v(@m.xm36.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9190 -4000 2 0 {name=r16 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9440 -4080 2 1 {name=r17 node=v(@m.xm44.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4170 2 0 {name=r19 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4170 2 1 {name=r20 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9370 -4300 2 1 {name=r21 node=v(@m.xm46.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4410 2 0 {name=r22 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4410 2 1 {name=r23 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4540 2 0 {name=r24 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4540 2 1 {name=r25 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9370 -4620 2 1 {name=r26 node=v(@m.xm45.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9360 -3820 2 0 {name=r29 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3780 2 0 {name=r30 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3690 2 0 {name=r31 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3650 2 0 {name=r32 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {lab_wire.sym} 9420 -3780 2 0 {name=p41 sig_type=std_logic lab=ERR_V_tail_btw
value=1110}
C {lab_wire.sym} 9600 -4130 0 1 {name=p42 sig_type=std_logic lab=ERR_AMP_Vd1}
C {lab_wire.sym} 9220 -4130 0 0 {name=p43 sig_type=std_logic lab=ERR_AMP_Vd2}
C {lab_pin.sym} 8440 -4350 0 0 {name=p37 lab=ERR_AMP_OUT}
C {res.sym} 10320 -4230 0 0 {name=R46
value=10000
footprint=1206
device=resistor
m=1}
C {capa.sym} 8620 -4080 3 0 {name=C3
m=1
value=0.5n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 8800 -4080 3 0 {name=R47
value=16700
footprint=1206
device=resistor
m=1}
C {capa.sym} 8660 -4010 3 1 {name=C4
m=1
value=7n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10470 -4310 0 0 {name=R48
value=7000
footprint=1206
device=resistor
m=1}
C {capa.sym} 10470 -4120 0 0 {name=C5
m=1
value=1.1n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10390 -3950 0 0 {name=R49
value=1000
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 10390 -3830 0 1 {name=l46 lab=GND
value=1110}
C {lab_pin.sym} 9930 -4040 0 1 {name=p26 lab=ERR_AMP_REF}
C {lab_wire.sym} 9070 -4040 2 1 {name=p59 sig_type=std_logic lab=ERR_AMP_VIN}
C {lab_wire.sym} 10320 -4040 2 1 {name=p60 sig_type=std_logic lab=ERR_AMP_VIN}
C {devices/vsource.sym} 10190 -3390 0 0 {name=V3 value=0.9 savecurrent=false
* 1.4 0.907 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 10190 -3360 0 0 {name=V4 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 10190 -3470 0 1 {name=p61 lab=ERR_AMP_REF}
C {lab_wire.sym} 10390 -4610 0 1 {name=p58 sig_type=std_logic lab=V_CONVERTER_OUT}
C {devices/gnd.sym} 7340 -1950 0 1 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7500 -2070 0 0 {name=M58
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7160 -2070 0 1 {name=M59
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7120 -2450 0 0 {name=M60
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7540 -2450 0 1 {name=M61
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7120 -2310 0 0 {name=M62
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7540 -2310 0 1 {name=M63
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7140 -2210 0 0 {name=p44 lab=ST_AMP_OUT}
C {lab_pin.sym} 7520 -2210 0 1 {name=p46 lab=ST_AMP_MIR}
C {devices/ngspice_get_value.sym} 7500 -2040 2 0 {name=r33 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7160 -2040 2 1 {name=r34 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7500 -2280 2 0 {name=r35 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7160 -2280 2 1 {name=r36 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7500 -2410 2 0 {name=r37 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7160 -2410 2 1 {name=r38 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 6680 -2070 0 1 {name=M64
W=2
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5580 -2070 0 1 {name=M65
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5580 -2310 0 1 {name=M66
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5540 -2280 2 0 {name=r39 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6670 -2040 2 1 {name=r40 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5570 -2040 2 1 {name=r41 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 5560 -2430 0 1 {name=l40 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 7350 -2660 0 1 {name=M67
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7340 -2630 2 1 {name=r42 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7510 -2660 0 1 {name=p48 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 6660 -2200 0 1 {name=p49 sig_type=std_logic lab=ST_PULL_DOWN}
C {devices/vdd.sym} 7330 -2780 0 1 {name=l41 lab=VDD}
C {lab_wire.sym} 7410 -2550 0 1 {name=p50 sig_type=std_logic lab=ST_Vp}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2660 0 1 {name=M68
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6670 -2630 2 1 {name=r43 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 6790 -2660 0 1 {name=p51 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6660 -3080 0 1 {name=l42 lab=VDD}
C {lab_pin.sym} 7140 -2370 0 0 {name=p52 lab=ST_VD2}
C {lab_pin.sym} 7520 -2370 0 1 {name=p53 lab=ST_VD1}
C {lab_pin.sym} 7030 -2450 0 0 {name=p55 lab=ST_V_REF}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7860 -2290 0 1 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=270 spiceprefix=X}
C {devices/gnd.sym} 7860 -2170 0 1 {name=l43 lab=GND}
C {devices/ngspice_get_value.sym} 8110 -2260 2 1 {name=r44 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 7860 -2390 0 1 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 8120 -2290 0 1 {name=M69
W=4.0
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8010 -2290 0 1 {name=l44 lab=GND}
C {lab_wire.sym} 8230 -2290 0 1 {name=p57 sig_type=std_logic lab=S_RST}
C {lab_wire.sym} 7640 -2450 2 0 {name=p47 sig_type=std_logic lab=V_SAWTOOTH}
C {sky130_fd_pr/pfet_01v8.sym} 8000 -2560 0 1 {name=M70
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7990 -2530 2 1 {name=r45 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8160 -2560 0 1 {name=p56 sig_type=std_logic lab=Vbias1}
C {sky130_fd_pr/pfet_01v8.sym} 8000 -2680 0 1 {name=M71
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8000 -3010 0 1 {name=M72
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7980 -3160 0 1 {name=l45 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 8000 -2860 0 1 {name=M73
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6090 -2120 3 0 {name=M74
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6090 -2320 3 1 {name=M75
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6090 -2070 2 1 {name=l47 lab=VDD}
C {devices/gnd.sym} 6090 -2370 2 1 {name=l48 lab=GND}
C {lab_wire.sym} 5680 -2200 0 1 {name=p64 sig_type=std_logic lab=ST_PULL_DOWN2}
C {sky130_fd_pr/nfet_01v8.sym} 6240 -2120 3 0 {name=M76
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6240 -2320 3 1 {name=M77
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6240 -2070 2 1 {name=l49 lab=VDD}
C {devices/gnd.sym} 6240 -2370 2 1 {name=l50 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6390 -2120 3 0 {name=M78
W=8
L=0.3
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6390 -2320 3 1 {name=M79
W=8
L=0.3
nf=4
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 6390 -2070 2 1 {name=l51 lab=VDD}
C {devices/gnd.sym} 6390 -2370 2 1 {name=l52 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2810 0 1 {name=M80
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6670 -2780 2 1 {name=r50 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2960 0 1 {name=M81
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6670 -2930 2 1 {name=r51 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 6530 -2200 3 1 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {lab_wire.sym} 6920 -4370 0 1 {name=p31 sig_type=std_logic lab=Vbias1}
C {sky130_fd_pr/pfet_01v8.sym} 6810 -4370 0 1 {name=M52
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6800 -4340 2 1 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6790 -4790 0 1 {name=l34 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 6810 -4520 0 1 {name=M82
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6800 -4490 2 1 {name=r52 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 6810 -4670 0 1 {name=M83
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6800 -4640 2 1 {name=r53 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 8530 -4160 0 1 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {ammeter.sym} 9220 -4280 0 1 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {ammeter.sym} 8710 -4080 3 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {ammeter.sym} 8770 -4010 3 1 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {lab_wire.sym} 8660 -4160 0 1 {name=p63 sig_type=std_logic lab=INT_BTW}
C {lab_wire.sym} 9600 -4510 0 1 {name=p65 sig_type=std_logic lab=ERR_AMP_Vd3}
C {lab_wire.sym} 9220 -4510 0 0 {name=p66 sig_type=std_logic lab=ERR_AMP_Vd4}
C {lab_wire.sym} 9090 -4350 0 0 {name=p67 sig_type=std_logic lab=ERR_AMP_OUT}
C {ammeter.sym} 10470 -4220 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {ammeter.sym} 10320 -4120 0 1 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/vsource.sym} 10220 -2710 0 1 {name=V12 value=25 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {res.sym} 11890 -2240 0 0 {name=R27
value=1
footprint=1206
device=resistor
m=1}
C {ind.sym} 11520 -2750 1 0 {name=L53
m=1
value=30u
footprint=1206
device=inductor}
C {capa.sym} 11740 -2000 0 0 {name=C6
m=1
value=250u
footprint=1206
device="ceramic capacitor"}
C {res.sym} 11740 -2430 0 0 {name=R28
value=0.05
footprint=1206
device=resistor
m=1}
C {gnd.sym} 11270 -2770 0 0 {name=l55 lab=GND}
C {switch_ngspice.sym} 11310 -2810 0 0 {name=S1 model=SW1
device_model=".MODEL SW1 SW( VT=0.9 VH=0.01 RON=0.01 ROFF=10G )"}
C {lab_pin.sym} 11890 -2750 2 0 {name=p68 sig_type=std_logic lab=V_CONVERTER_OUT}
C {gnd.sym} 11490 -1630 0 0 {name=l56 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6490 -3920 0 1 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6490 -4160 0 1 {name=M36
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6450 -4130 2 0 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6480 -3890 2 1 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6470 -4280 0 1 {name=l33 lab=VDD}
C {lab_wire.sym} 6240 -4050 0 0 {name=p19 sig_type=std_logic lab=SW_IN}
C {lab_wire.sym} 6790 -4050 0 1 {name=p62 sig_type=std_logic lab=PMW_PULL_DOWN}
C {lab_wire.sym} 10760 -2970 0 0 {name=p23 sig_type=std_logic lab=buck_vin}
C {lab_wire.sym} 11310 -2520 0 0 {name=p69 sig_type=std_logic lab=V_DIODE}
C {lab_wire.sym} 10790 -2810 0 0 {name=p45 sig_type=std_logic lab=PMW_PULL_DOWN}
C {gnd.sym} 11270 -2200 0 1 {name=l54 lab=GND}
C {switch_ngspice.sym} 11310 -2240 0 0 {name=S2 model=SW1
device_model=".MODEL SW1 SW( VT=0.9 VH=0.01 RON=0.01 ROFF=10G )"}
C {lab_wire.sym} 11160 -2240 0 1 {name=p54 sig_type=std_logic lab=SW1_INV}
C {vcvs.sym} 11000 -2210 0 0 {name=E1 value=-1}
C {gnd.sym} 11000 -2160 0 0 {name=l57 lab=GND}
C {gnd.sym} 10960 -2170 0 1 {name=l58 lab=GND}
C {devices/vsource.sym} 11110 -2240 1 1 {name=V6 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
