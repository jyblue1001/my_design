v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 9820 -3930 10080 -3740 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.084















color=7
node=err_amp_vin}
B 2 9820 -3690 10080 -3500 {flags=graph

y2=0.92
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.88
















color="7 6"
node="err_amp_vin
err_amp_ref"}
B 2 8510 -4620 8770 -4430 {flags=graph

y2=2.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.82


















color="7 6"
node="err_amp_out
err_amp_amp_mir"}
B 2 7800 -4230 8060 -4040 {flags=graph

y2=2.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.68


















color=7
node=err_amp_out}
B 2 9820 -4330 10080 -4140 {flags=graph

y2=14
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.54















color=7
node=v_converter_out}
B 2 5900 -3740 6160 -3550 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-1.5e-05






















color=6
node=sw_in}
B 2 13090 -2510 13350 -2320 {flags=graph

y2=14
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0

divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.54















color=12
node=v_converter_out
x2=0.001}
B 2 7000 -3740 7260 -3550 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.045






















color=6
node=v_sawtooth}
B 2 6350 -3740 6610 -3550 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.014























color=7
node=pmw_pull_down}
B 2 6350 -3520 6610 -3330 {flags=graph

y2=40
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-14















color=7
node=v_converter_out}
B 2 12210 -2510 12470 -2320 {flags=graph

y2=26
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.43

















color=7
node=v_diode}
B 2 11920 -2880 12180 -2690 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0016
























color=6
node=sw_in}
B 2 9820 -4550 10080 -4360 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.012























color=7
node=pmw_pull_down}
B 2 11920 -2290 12180 -2100 {flags=graph

y2=1300
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.99


















color=6
node=i(@s1[i])}
B 2 9020 -3900 9280 -3710 {flags=graph

y2=4.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=4e-05
















color="6 7"
node="i(@m.xm37.msky130_fd_pr__nfet_01v8[id])
i(@m.xm44.msky130_fd_pr__nfet_01v8[id])"}
B 2 8700 -3900 8960 -3710 {flags=graph

y2=3.8e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=8.4e-14
















color="6 7"
node="i(@m.xm46.msky130_fd_pr__nfet_01v8[id])
i(@m.xm45.msky130_fd_pr__nfet_01v8[id])"}
B 2 7800 -4570 8060 -4380 {flags=graph

y2=4.7e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=3.8e-13



















color=7
node=i(@m.xm49.msky130_fd_pr__pfet_01v8[id])}
B 2 12210 -2290 12470 -2100 {flags=graph

y2=1300
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-43


















color=7
node=i(@s2[i])}
B 2 11920 -2510 12180 -2320 {flags=graph

y2=26
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.094


















color=6
node="\\"buck_vin v_diode -\\""}
B 2 12500 -2290 12760 -2100 {flags=graph

y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-43



















color=9
node=i(l53)}
B 2 12500 -2510 12760 -2320 {flags=graph

y2=25
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-14


















color=9
node="\\"v_diode v_converter_out - \\""}
B 2 12790 -2290 13050 -2100 {flags=graph

y2=36
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-13




















color=11
node=i(@c6[i])}
B 2 12790 -2510 13050 -2320 {flags=graph

y2=14
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.15



















color=11
node=v_cap}
B 2 7610 -5760 7870 -5570 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=3.1e-07




















color=7
node=sw_in_delay}
B 2 7610 -5550 7870 -5360 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.033




















color=7
node=s_rst}
B 2 7890 -5760 8150 -5570 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.014




















color=6
node=q}
B 2 7890 -5550 8150 -5360 {flags=graph

y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.033




















color=6
node=q_b}
B 2 10970 -2370 11230 -2180 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.015
























color="6 7"
node="sw_in
q"}
B 2 7610 -5960 7870 -5770 {flags=graph

y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=0.001
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.0004




















color=7
node=sw_in}
T {r=7769} 2230 -2880 0 0 0.4 0.4 {}
T {Voltage} 11770 -2450 0 0 0.6 0.6 {}
T {Current} 11770 -2220 0 0 0.6 0.6 {}
T {Switch} 11990 -2610 0 0 0.6 0.6 {}
T { Diode
(Switch)} 12290 -2610 0 0 0.6 0.6 {}
T {Inductor} 12570 -2610 0 0 0.6 0.6 {}
T {Capacitor} 12850 -2610 0 0 0.6 0.6 {}
T {Load Resistor} 13120 -2610 0 0 0.6 0.6 {}
T {Duty Cycle} 11740 -2810 0 0 0.6 0.6 {}
N 7360 -2470 7360 -2420 {lab=ST_V_REF}
N 5980 -3920 5980 -3820 {lab=GND}
N 5980 -3820 6020 -3820 {lab=GND}
N 5980 -3920 6020 -3920 {lab=GND}
N 6020 -3890 6020 -3820 {lab=GND}
N 6020 -4340 6020 -3950 {lab=PMW_PULL_DOWN}
N 5200 -4000 5200 -3980 {lab=VDD}
N 5200 -3920 5200 -3900 {lab=GND}
N 1180 -3430 1180 -2810 {lab=V_REF_MIR}
N 2130 -3430 2130 -2810 {lab=V_REF}
N 1180 -3560 1180 -3490 {lab=VDD}
N 2130 -3560 2130 -3490 {lab=VDD}
N 1180 -2750 1180 -2680 {lab=GND}
N 2130 -2750 2130 -2680 {lab=V_RES}
N 1180 -2870 1290 -2870 {lab=V_REF_MIR}
N 1290 -2870 1290 -2780 {lab=V_REF_MIR}
N 2130 -3460 2170 -3460 {lab=VDD}
N 2170 -3520 2170 -3460 {lab=VDD}
N 2130 -3520 2170 -3520 {lab=VDD}
N 1140 -3460 1180 -3460 {lab=VDD}
N 1140 -3520 1140 -3460 {lab=VDD}
N 1140 -3520 1180 -3520 {lab=VDD}
N 1140 -2720 1180 -2720 {lab=GND}
N 1140 -2780 1140 -2720 {lab=GND}
N 1140 -2780 1180 -2780 {lab=GND}
N 2130 -2780 2260 -2780 {lab=GND}
N 730 -3120 730 -2950 {lab=START_UP}
N 730 -3250 730 -3180 {lab=VDD}
N 690 -3150 730 -3150 {lab=VDD}
N 690 -3210 690 -3150 {lab=VDD}
N 690 -3210 730 -3210 {lab=VDD}
N 690 -2920 690 -2860 {lab=GND}
N 690 -2920 730 -2920 {lab=GND}
N 920 -3070 990 -3070 {lab=GND}
N 730 -3070 880 -3070 {lab=START_UP}
N 770 -3150 800 -3150 {lab=START_UP}
N 800 -3150 800 -3070 {lab=START_UP}
N 920 -3110 920 -3100 {lab=Vbiasp}
N 920 -3040 920 -3030 {lab=V_REF_MIR}
N 920 -3030 1180 -3030 {lab=V_REF_MIR}
N 2070 -2650 2110 -2650 {lab=GND}
N 2130 -2620 2130 -2540 {lab=GND}
N 770 -2920 1180 -2920 {lab=V_REF_MIR}
N 730 -2890 730 -2810 {lab=GND}
N 730 -2810 730 -2690 {lab=GND}
N 690 -2860 730 -2860 {lab=GND}
N 1430 -3610 1430 -2630 {lab=Vbiasp_MIR}
N 1810 -3610 1810 -2630 {lab=Vbiasp}
N 1470 -3640 1770 -3640 {lab=Vbiasp_MIR}
N 1430 -3740 1430 -3670 {lab=VDD}
N 1810 -3740 1810 -3670 {lab=VDD}
N 1430 -2570 1430 -2500 {lab=GND}
N 1810 -2570 1810 -2500 {lab=GND}
N 1810 -3640 1850 -3640 {lab=VDD}
N 1850 -3700 1850 -3640 {lab=VDD}
N 1810 -3700 1850 -3700 {lab=VDD}
N 1390 -3640 1430 -3640 {lab=VDD}
N 1390 -3700 1390 -3640 {lab=VDD}
N 1390 -3700 1430 -3700 {lab=VDD}
N 1390 -2540 1430 -2540 {lab=GND}
N 1390 -2600 1390 -2540 {lab=GND}
N 1390 -2600 1430 -2600 {lab=GND}
N 1810 -2540 1850 -2540 {lab=GND}
N 1850 -2600 1850 -2540 {lab=GND}
N 1810 -2600 1850 -2600 {lab=GND}
N 1610 -3640 1610 -3530 {lab=Vbiasp_MIR}
N 1430 -3530 1610 -3530 {lab=Vbiasp_MIR}
N 1220 -2780 1290 -2780 {lab=V_REF_MIR}
N 1290 -2780 1640 -2780 {lab=V_REF_MIR}
N 1640 -2780 1770 -2600 {lab=V_REF_MIR}
N 1470 -2600 1710 -2780 {lab=V_REF}
N 1710 -2780 2090 -2780 {lab=V_REF}
N 2010 -2870 2010 -2780 {lab=V_REF}
N 2010 -2870 2130 -2870 {lab=V_REF}
N 1220 -3460 1810 -3460 {lab=Vbiasp}
N 1810 -3460 2090 -3460 {lab=Vbiasp}
N 920 -3110 1810 -3110 {lab=Vbiasp}
N 2530 -2620 2530 -2550 {lab=GND}
N 2490 -2590 2530 -2590 {lab=GND}
N 2490 -2650 2490 -2590 {lab=GND}
N 2490 -2650 2530 -2650 {lab=GND}
N 2530 -3280 2530 -3210 {lab=VDD}
N 2530 -3180 2570 -3180 {lab=VDD}
N 2570 -3240 2570 -3180 {lab=VDD}
N 2530 -3240 2570 -3240 {lab=VDD}
N 2530 -3150 2530 -2680 {lab=Vbias3}
N 4300 -3280 4600 -3280 {lab=Vbias1}
N 4260 -3380 4260 -3310 {lab=VDD}
N 4640 -3380 4640 -3310 {lab=VDD}
N 4640 -3280 4680 -3280 {lab=VDD}
N 4680 -3340 4680 -3280 {lab=VDD}
N 4640 -3340 4680 -3340 {lab=VDD}
N 4220 -3280 4260 -3280 {lab=VDD}
N 4220 -3340 4220 -3280 {lab=VDD}
N 4220 -3340 4260 -3340 {lab=VDD}
N 4440 -3280 4440 -3170 {lab=Vbias1}
N 4260 -2830 4440 -2830 {lab=Vbias1}
N 4300 -3010 4600 -3010 {lab=Vbias2}
N 4260 -3110 4260 -3040 {lab=Vhigh}
N 4640 -3110 4640 -3040 {lab=#net1}
N 4640 -3010 4680 -3010 {lab=VDD}
N 4680 -3070 4680 -3010 {lab=VDD}
N 4220 -3010 4260 -3010 {lab=VDD}
N 4220 -3070 4220 -3010 {lab=VDD}
N 4260 -3250 4260 -3110 {lab=Vhigh}
N 4640 -3250 4640 -3110 {lab=#net1}
N 4440 -3170 4440 -2830 {lab=Vbias1}
N 4260 -2980 4260 -2760 {lab=Vbias1}
N 4640 -2980 4640 -2760 {lab=Vncas}
N 4160 -2920 4360 -2920 {lab=Vbias2}
N 4360 -3010 4360 -2920 {lab=Vbias2}
N 4260 -2330 4260 -2260 {lab=GND}
N 4260 -2300 4300 -2300 {lab=GND}
N 4300 -2360 4300 -2300 {lab=GND}
N 4260 -2360 4300 -2360 {lab=GND}
N 4260 -2450 4260 -2390 {lab=#net2}
N 4070 -2360 4220 -2360 {lab=Vbias4}
N 4640 -2550 4640 -2480 {lab=#net3}
N 4600 -2580 4600 -2520 {lab=GND}
N 4600 -2580 4640 -2580 {lab=GND}
N 4640 -2760 4640 -2610 {lab=Vncas}
N 4640 -2800 4950 -2800 {lab=Vncas}
N 4680 -2580 4770 -2580 {lab=Vncas}
N 4640 -2330 4640 -2260 {lab=#net4}
N 4680 -2360 4680 -2300 {lab=GND}
N 4640 -2360 4680 -2360 {lab=GND}
N 4640 -2480 4640 -2390 {lab=#net3}
N 4640 -2200 4640 -2130 {lab=GND}
N 4640 -2170 4680 -2170 {lab=GND}
N 4680 -2230 4680 -2170 {lab=GND}
N 4640 -2230 4680 -2230 {lab=GND}
N 4510 -2230 4600 -2230 {lab=#net3}
N 4600 -2520 4680 -2520 {lab=GND}
N 4680 -2520 4680 -2360 {lab=GND}
N 4680 -2300 4680 -2230 {lab=GND}
N 4510 -2440 4510 -2230 {lab=#net3}
N 4510 -2440 4640 -2440 {lab=#net3}
N 4220 -3280 4220 -3070 {lab=VDD}
N 4680 -3280 4680 -3070 {lab=VDD}
N 2870 -3280 2870 -3210 {lab=VDD}
N 2870 -3180 2910 -3180 {lab=VDD}
N 2910 -3240 2910 -3180 {lab=VDD}
N 2870 -3240 2910 -3240 {lab=VDD}
N 2870 -3010 2870 -2940 {lab=Vbias4}
N 2870 -3150 2870 -3010 {lab=Vbias4}
N 2870 -2880 2870 -2660 {lab=Vbias4}
N 2830 -2560 2830 -2500 {lab=GND}
N 2870 -2660 2870 -2590 {lab=Vbias4}
N 2830 -2560 2870 -2560 {lab=GND}
N 2870 -2530 2870 -2460 {lab=Vlow}
N 4440 -3210 4950 -3210 {lab=Vbias1}
N 2720 -3180 2720 -3110 {lab=Vbiasp}
N 2720 -3180 2830 -3180 {lab=Vbiasp}
N 2830 -2360 2830 -2300 {lab=GND}
N 2870 -2460 2870 -2390 {lab=Vlow}
N 2830 -2360 2870 -2360 {lab=GND}
N 2870 -2330 2870 -2260 {lab=GND}
N 2830 -2300 2870 -2300 {lab=GND}
N 2910 -2360 2990 -2360 {lab=Vbias4}
N 2990 -2720 2990 -2360 {lab=Vbias4}
N 2870 -2720 2990 -2720 {lab=Vbias4}
N 4360 -2920 4950 -2920 {lab=Vbias2}
N 4770 -2800 4770 -2580 {lab=Vncas}
N 2830 -2500 2830 -2360 {lab=GND}
N 3320 -3280 3320 -3210 {lab=VDD}
N 3320 -3180 3360 -3180 {lab=VDD}
N 3360 -3240 3360 -3180 {lab=VDD}
N 3320 -3240 3360 -3240 {lab=VDD}
N 3320 -3010 3320 -2940 {lab=Vds2}
N 3320 -2910 3360 -2910 {lab=VDD}
N 3360 -2970 3360 -2910 {lab=VDD}
N 3320 -3150 3320 -3010 {lab=Vds2}
N 3360 -2560 3360 -2500 {lab=GND}
N 3320 -2660 3320 -2590 {lab=Vpcas}
N 3360 -3180 3360 -2970 {lab=VDD}
N 3320 -2560 3360 -2560 {lab=GND}
N 3320 -2530 3320 -2460 {lab=Vds3}
N 3210 -3180 3210 -3110 {lab=Vgs2}
N 3210 -3180 3280 -3180 {lab=Vgs2}
N 3360 -2360 3360 -2300 {lab=GND}
N 3320 -2460 3320 -2390 {lab=Vds3}
N 3320 -2360 3360 -2360 {lab=GND}
N 3320 -2330 3320 -2260 {lab=GND}
N 3320 -2300 3360 -2300 {lab=GND}
N 3200 -2360 3280 -2360 {lab=Vbias4}
N 3110 -2910 3280 -2910 {lab=Vbias2}
N 3360 -2500 3360 -2360 {lab=GND}
N 2990 -2360 3200 -2360 {lab=Vbias4}
N 2910 -2560 3280 -2560 {lab=Vbias3}
N 3110 -2650 3110 -2560 {lab=Vbias3}
N 3320 -2780 3360 -2780 {lab=VDD}
N 3360 -2840 3360 -2780 {lab=VDD}
N 3210 -2780 3210 -2690 {lab=Vpcas}
N 3210 -2780 3280 -2780 {lab=Vpcas}
N 3360 -2910 3360 -2840 {lab=VDD}
N 3320 -2880 3320 -2810 {lab=Vgs2}
N 3210 -3110 3210 -2850 {lab=Vgs2}
N 3210 -2850 3320 -2850 {lab=Vgs2}
N 3320 -2750 3320 -2660 {lab=Vpcas}
N 3210 -2690 3320 -2690 {lab=Vpcas}
N 3320 -2690 3580 -2690 {lab=Vpcas}
N 4410 -2360 4600 -2360 {lab=Vbias3}
N 2390 -3110 2420 -3110 {lab=Vbiasp}
N 3110 -2650 3580 -2650 {lab=Vbias3}
N 2870 -2490 3580 -2490 {lab=Vlow}
N 2990 -2440 3580 -2440 {lab=Vbias4}
N 4260 -3130 4950 -3130 {lab=Vhigh}
N 1980 -3460 1980 -3370 {lab=Vbiasp}
N 2410 -3180 2490 -3180 {lab=Vbiasp}
N 1980 -3180 2410 -3180 {lab=Vbiasp}
N 1980 -3370 1980 -3180 {lab=Vbiasp}
N 2870 -2940 2870 -2880 {lab=Vbias4}
N 2570 -2650 2780 -2650 {lab=Vbias3}
N 2640 -2760 2640 -2650 {lab=Vbias3}
N 2530 -2760 2640 -2760 {lab=Vbias3}
N 2420 -3110 2720 -3110 {lab=Vbiasp}
N 2390 -3180 2390 -3110 {lab=Vbiasp}
N 2780 -2650 3110 -2650 {lab=Vbias3}
N 4260 -2540 4260 -2450 {lab=#net2}
N 4260 -2570 4300 -2570 {lab=GND}
N 4260 -2760 4260 -2600 {lab=Vbias1}
N 4300 -2570 4300 -2360 {lab=GND}
N 4070 -2570 4220 -2570 {lab=Vbias3}
N 3870 -2920 3910 -2920 {lab=VDD}
N 3910 -2890 3910 -2760 {lab=Vbias2}
N 3910 -2330 3910 -2260 {lab=GND}
N 3910 -2300 3950 -2300 {lab=GND}
N 3950 -2360 3950 -2300 {lab=GND}
N 3910 -2360 3950 -2360 {lab=GND}
N 3910 -2450 3910 -2390 {lab=#net5}
N 3720 -2360 3870 -2360 {lab=Vbias4}
N 3910 -2540 3910 -2450 {lab=#net5}
N 3910 -2570 3950 -2570 {lab=GND}
N 3910 -2760 3910 -2600 {lab=Vbias2}
N 3950 -2570 3950 -2360 {lab=GND}
N 3720 -2570 3870 -2570 {lab=Vbias3}
N 3910 -3020 3910 -2950 {lab=VDD}
N 3870 -2980 3870 -2920 {lab=VDD}
N 3870 -2980 3910 -2980 {lab=VDD}
N 3950 -2920 4160 -2920 {lab=Vbias2}
N 4000 -2920 4000 -2830 {lab=Vbias2}
N 3910 -2830 4000 -2830 {lab=Vbias2}
N 3580 -2650 3720 -2650 {lab=Vbias3}
N 3720 -2650 3720 -2570 {lab=Vbias3}
N 3580 -2440 3720 -2440 {lab=Vbias4}
N 3720 -2440 3720 -2360 {lab=Vbias4}
N 4070 -2650 4070 -2570 {lab=Vbias3}
N 4070 -2440 4070 -2360 {lab=Vbias4}
N 3720 -2440 4070 -2440 {lab=Vbias4}
N 3720 -2650 4070 -2650 {lab=Vbias3}
N 4070 -2650 4410 -2650 {lab=Vbias3}
N 4410 -2650 4410 -2360 {lab=Vbias3}
N 2300 -3410 2300 -3320 {lab=VDD}
N 2300 -3260 2300 -3180 {lab=Vbiasp}
N 9420 -3690 9420 -3620 {lab=GND}
N 9380 -3660 9420 -3660 {lab=GND}
N 9380 -3720 9380 -3660 {lab=GND}
N 9380 -3720 9420 -3720 {lab=GND}
N 9380 -3860 9380 -3800 {lab=GND}
N 9380 -3860 9420 -3860 {lab=GND}
N 9420 -3830 9420 -3750 {lab=ERR_V_tail_btw}
N 9380 -3800 9380 -3720 {lab=GND}
N 9260 -4200 9560 -4200 {lab=ERR_AMP_Vb1}
N 9260 -4580 9560 -4580 {lab=ERR_AMP_AMP_MIR}
N 9600 -4680 9600 -4610 {lab=VDD}
N 9220 -4680 9220 -4610 {lab=VDD}
N 9180 -4580 9220 -4580 {lab=VDD}
N 9180 -4640 9180 -4580 {lab=VDD}
N 9180 -4640 9220 -4640 {lab=VDD}
N 9600 -4580 9640 -4580 {lab=VDD}
N 9640 -4640 9640 -4580 {lab=VDD}
N 9600 -4640 9640 -4640 {lab=VDD}
N 9260 -4440 9560 -4440 {lab=Vbias2}
N 9180 -4440 9220 -4440 {lab=VDD}
N 9600 -4440 9640 -4440 {lab=VDD}
N 9640 -4580 9640 -4440 {lab=VDD}
N 9180 -4580 9180 -4440 {lab=VDD}
N 9600 -4170 9600 -4070 {lab=ERR_AMP_Vd1}
N 9220 -4170 9220 -4070 {lab=ERR_AMP_Vd2}
N 9600 -4550 9600 -4470 {lab=ERR_AMP_Vd3}
N 9220 -4550 9220 -4470 {lab=ERR_AMP_Vd4}
N 9600 -4410 9600 -4230 {lab=ERR_AMP_AMP_MIR}
N 9600 -4200 9680 -4200 {lab=GND}
N 9140 -4200 9220 -4200 {lab=GND}
N 9600 -4010 9600 -3950 {lab=ERR_AMP_Vp}
N 9220 -3950 9600 -3950 {lab=ERR_AMP_Vp}
N 9220 -4010 9220 -3950 {lab=ERR_AMP_Vp}
N 9420 -3950 9420 -3890 {lab=ERR_AMP_Vp}
N 9380 -4040 9380 -3860 {lab=GND}
N 9220 -4040 9380 -4040 {lab=GND}
N 9380 -4040 9600 -4040 {lab=GND}
N 9420 -4080 9420 -3950 {lab=ERR_AMP_Vp}
N 9380 -4110 9420 -4110 {lab=GND}
N 9380 -4110 9380 -4040 {lab=GND}
N 9420 -4200 9420 -4140 {lab=ERR_AMP_Vb1}
N 9460 -4110 9490 -4110 {lab=ERR_AMP_Vb1}
N 9490 -4160 9490 -4110 {lab=ERR_AMP_Vb1}
N 9420 -4160 9490 -4160 {lab=ERR_AMP_Vb1}
N 9520 -4260 9600 -4260 {lab=ERR_AMP_AMP_MIR}
N 9520 -4580 9520 -4260 {lab=ERR_AMP_AMP_MIR}
N 9310 -4650 9350 -4650 {lab=VDD}
N 9310 -4340 9350 -4340 {lab=VDD}
N 9350 -4620 9350 -4370 {lab=#net6}
N 9310 -4650 9310 -4340 {lab=VDD}
N 9350 -4310 9350 -4200 {lab=ERR_AMP_Vb1}
N 9350 -4750 9350 -4680 {lab=VDD}
N 9310 -4710 9310 -4650 {lab=VDD}
N 9310 -4710 9350 -4710 {lab=VDD}
N 9390 -4340 9430 -4340 {lab=Vbias2}
N 9430 -4440 9430 -4340 {lab=Vbias2}
N 9390 -4650 9470 -4650 {lab=Vbias1}
N 9460 -3860 9590 -3860 {lab=Vbias3}
N 9460 -3720 9590 -3720 {lab=Vbias4}
N 8950 -4040 9180 -4040 {lab=ERR_AMP_VIN}
N 9640 -4040 9930 -4040 {lab=ERR_AMP_REF}
N 10320 -4410 10320 -4260 {lab=V_CONVERTER_OUT}
N 10320 -4410 10470 -4410 {lab=V_CONVERTER_OUT}
N 10470 -4410 10470 -4340 {lab=V_CONVERTER_OUT}
N 10320 -4040 10470 -4040 {lab=ERR_AMP_VIN}
N 10470 -4090 10470 -4040 {lab=ERR_AMP_VIN}
N 10390 -3920 10390 -3830 {lab=GND}
N 10390 -4040 10390 -3980 {lab=ERR_AMP_VIN}
N 10390 -4610 10390 -4410 {lab=V_CONVERTER_OUT}
N 8570 -4010 8630 -4010 {lab=#net7}
N 8570 -4080 8570 -4010 {lab=#net7}
N 8570 -4080 8590 -4080 {lab=#net7}
N 8830 -4080 8850 -4080 {lab=ERR_AMP_VIN}
N 8850 -4080 8850 -4010 {lab=ERR_AMP_VIN}
N 10250 -3940 10250 -3890 {lab=ERR_AMP_REF}
N 6100 -4370 6150 -4370 {lab=Vbias1}
N 5980 -4370 6020 -4370 {lab=VDD}
N 6060 -4370 6100 -4370 {lab=Vbias1}
N 5980 -4450 5980 -4370 {lab=VDD}
N 6020 -4490 6020 -4400 {lab=#net8}
N 5980 -4520 6020 -4520 {lab=VDD}
N 6060 -4520 6100 -4520 {lab=Vbias1}
N 5980 -4600 5980 -4520 {lab=VDD}
N 6020 -4640 6020 -4550 {lab=#net9}
N 5980 -4670 6020 -4670 {lab=VDD}
N 6060 -4670 6100 -4670 {lab=Vbias1}
N 5980 -4750 6020 -4750 {lab=VDD}
N 5980 -4750 5980 -4670 {lab=VDD}
N 6020 -4790 6020 -4700 {lab=VDD}
N 5980 -4670 5980 -4600 {lab=VDD}
N 6100 -4670 6100 -4520 {lab=Vbias1}
N 5980 -4520 5980 -4450 {lab=VDD}
N 6100 -4520 6100 -4370 {lab=Vbias1}
N 8850 -4040 8950 -4040 {lab=ERR_AMP_VIN}
N 8530 -4040 8570 -4040 {lab=#net7}
N 8530 -4130 8530 -4040 {lab=#net7}
N 9220 -4250 9220 -4230 {lab=#net10}
N 9220 -4410 9220 -4310 {lab=ERR_AMP_OUT}
N 8860 -4350 9220 -4350 {lab=ERR_AMP_OUT}
N 8440 -4350 8800 -4350 {lab=ERR_AMP_OUT}
N 8530 -4350 8530 -4190 {lab=ERR_AMP_OUT}
N 8740 -4080 8770 -4080 {lab=#net11}
N 8650 -4080 8680 -4080 {lab=INT_BTW}
N 8690 -4010 8740 -4010 {lab=#net12}
N 8800 -4010 8850 -4010 {lab=ERR_AMP_VIN}
N 8660 -4160 8660 -4080 {lab=INT_BTW}
N 10320 -4090 10320 -4040 {lab=ERR_AMP_VIN}
N 10320 -4200 10320 -4150 {lab=#net13}
N 10470 -4190 10470 -4150 {lab=#net14}
N 10470 -4280 10470 -4250 {lab=#net15}
N 8800 -4350 8860 -4350 {lab=ERR_AMP_OUT}
N 10890 -2660 10890 -2370 {lab=V_DIODE}
N 10890 -2850 10890 -2720 {lab=buck_vin}
N 10220 -2850 10890 -2850 {lab=buck_vin}
N 10220 -2850 10220 -2760 {lab=buck_vin}
N 10890 -2540 11070 -2540 {lab=V_DIODE}
N 11130 -2540 11320 -2540 {lab=V_CONVERTER_OUT}
N 10890 -2310 10890 -2120 {lab=GND}
N 10890 -2120 11320 -2120 {lab=GND}
N 11320 -2200 11320 -2120 {lab=GND}
N 11320 -2540 11520 -2540 {lab=V_CONVERTER_OUT}
N 11520 -2540 11520 -2360 {lab=V_CONVERTER_OUT}
N 11520 -2300 11520 -2120 {lab=GND}
N 11320 -2120 11520 -2120 {lab=GND}
N 11320 -2390 11320 -2260 {lab=V_CAP}
N 11320 -2540 11320 -2450 {lab=V_CONVERTER_OUT}
N 10220 -2760 10220 -2620 {lab=buck_vin}
N 10220 -2560 10220 -2120 {lab=GND}
N 10220 -2120 10890 -2120 {lab=GND}
N 10850 -2670 10850 -2650 {lab=GND}
N 10370 -2690 10850 -2690 {lab=SW_IN_delay}
N 10460 -2330 10540 -2330 {lab=SW_IN_delay}
N 10460 -2690 10460 -2330 {lab=SW_IN_delay}
N 5660 -3920 5660 -3820 {lab=GND}
N 5660 -3820 5700 -3820 {lab=GND}
N 5660 -3920 5700 -3920 {lab=GND}
N 5700 -3890 5700 -3820 {lab=GND}
N 5790 -4000 5790 -3920 {lab=PMW_PULL_DOWN}
N 5740 -3920 5790 -3920 {lab=PMW_PULL_DOWN}
N 5700 -4130 5700 -3950 {lab=SW_IN}
N 5790 -4160 5790 -4000 {lab=PMW_PULL_DOWN}
N 5740 -4160 5790 -4160 {lab=PMW_PULL_DOWN}
N 5660 -4230 5660 -4160 {lab=VDD}
N 5660 -4160 5700 -4160 {lab=VDD}
N 5700 -4230 5700 -4190 {lab=VDD}
N 5660 -4230 5700 -4230 {lab=VDD}
N 5700 -4280 5700 -4230 {lab=VDD}
N 5790 -4050 6020 -4050 {lab=PMW_PULL_DOWN}
N 5470 -4050 5700 -4050 {lab=SW_IN}
N 5700 -3820 5980 -3820 {lab=GND}
N 10850 -2320 10850 -2300 {lab=GND}
N 10580 -2280 10580 -2260 {lab=GND}
N 10540 -2290 10540 -2270 {lab=GND}
N 10580 -2340 10660 -2340 {lab=#net16}
N 7220 -2610 7220 -2540 {lab=ST_Vp}
N 6840 -2610 6840 -2540 {lab=ST_Vp}
N 7220 -2480 7220 -2400 {lab=ST_VD1}
N 6840 -2480 6840 -2400 {lab=ST_VD2}
N 6740 -2030 7330 -2030 {lab=GND}
N 7040 -2030 7040 -2000 {lab=GND}
N 7260 -2510 7320 -2510 {lab=ST_V_REF}
N 6730 -2510 6800 -2510 {lab=V_SAWTOOTH}
N 7400 -2130 7400 -2030 {lab=GND}
N 7330 -2030 7400 -2030 {lab=GND}
N 7330 -2130 7400 -2130 {lab=GND}
N 6670 -2130 6670 -2030 {lab=GND}
N 6670 -2030 6740 -2030 {lab=GND}
N 6670 -2130 6740 -2130 {lab=GND}
N 6840 -2510 7220 -2510 {lab=VDD}
N 7330 -2100 7330 -2030 {lab=GND}
N 6740 -2100 6740 -2030 {lab=GND}
N 6110 -2130 6110 -2030 {lab=GND}
N 6110 -2030 6150 -2030 {lab=GND}
N 6110 -2130 6150 -2130 {lab=GND}
N 6150 -2100 6150 -2030 {lab=GND}
N 5680 -2130 5680 -2030 {lab=GND}
N 5680 -2030 5720 -2030 {lab=GND}
N 5680 -2130 5720 -2130 {lab=GND}
N 5720 -2100 5720 -2030 {lab=GND}
N 6150 -2690 6150 -2160 {lab=ST_PULL_DOWN}
N 5810 -2210 5810 -2130 {lab=ST_PULL_DOWN2}
N 5760 -2130 5810 -2130 {lab=ST_PULL_DOWN2}
N 5720 -2340 5720 -2160 {lab=S_RST}
N 5810 -2370 5810 -2210 {lab=ST_PULL_DOWN2}
N 5760 -2370 5810 -2370 {lab=ST_PULL_DOWN2}
N 5680 -2440 5680 -2370 {lab=VDD}
N 5680 -2370 5720 -2370 {lab=VDD}
N 5720 -2440 5720 -2400 {lab=VDD}
N 5680 -2440 5720 -2440 {lab=VDD}
N 5720 -2490 5720 -2440 {lab=VDD}
N 6840 -2610 7220 -2610 {lab=ST_Vp}
N 7030 -2690 7030 -2610 {lab=ST_Vp}
N 5720 -2030 6110 -2030 {lab=GND}
N 6990 -2720 7030 -2720 {lab=VDD}
N 7070 -2720 7110 -2720 {lab=Vbias1}
N 7110 -2720 7210 -2720 {lab=Vbias1}
N 6990 -2720 6990 -2510 {lab=VDD}
N 6990 -2800 7030 -2800 {lab=VDD}
N 7030 -2840 7030 -2750 {lab=VDD}
N 6990 -2800 6990 -2720 {lab=VDD}
N 6110 -2720 6150 -2720 {lab=VDD}
N 6190 -2720 6230 -2720 {lab=Vbias1}
N 6230 -2720 6280 -2720 {lab=Vbias1}
N 6110 -2800 6110 -2720 {lab=VDD}
N 6150 -2840 6150 -2750 {lab=#net17}
N 5480 -2260 5500 -2260 {lab=S_RST}
N 7870 -2320 7870 -2220 {lab=GND}
N 8070 -2280 8110 -2280 {lab=GND}
N 8110 -2320 8110 -2280 {lab=GND}
N 7870 -2280 8070 -2280 {lab=GND}
N 7870 -2510 8110 -2510 {lab=V_SAWTOOTH}
N 8110 -2510 8110 -2380 {lab=V_SAWTOOTH}
N 7810 -2510 7870 -2510 {lab=V_SAWTOOTH}
N 8020 -2350 8110 -2350 {lab=GND}
N 7870 -2420 7870 -2380 {lab=#net18}
N 7870 -2510 7870 -2480 {lab=V_SAWTOOTH}
N 7690 -2510 7810 -2510 {lab=V_SAWTOOTH}
N 5480 -2260 5480 -1860 {lab=S_RST}
N 5480 -1860 8080 -1860 {lab=S_RST}
N 8240 -2350 8240 -1860 {lab=S_RST}
N 8150 -2350 8240 -2350 {lab=S_RST}
N 7990 -2590 7990 -2510 {lab=V_SAWTOOTH}
N 7950 -2620 7990 -2620 {lab=VDD}
N 8030 -2620 8070 -2620 {lab=Vbias1}
N 8070 -2620 8170 -2620 {lab=Vbias1}
N 7770 -2930 7770 -2510 {lab=V_SAWTOOTH}
N 7990 -2710 7990 -2650 {lab=#net19}
N 7950 -2740 7990 -2740 {lab=VDD}
N 7990 -2860 7990 -2770 {lab=#net20}
N 7950 -2740 7950 -2620 {lab=VDD}
N 7950 -3070 7990 -3070 {lab=VDD}
N 7990 -3190 7990 -3100 {lab=VDD}
N 7950 -2890 7950 -2740 {lab=VDD}
N 7950 -3190 7950 -3070 {lab=VDD}
N 7950 -3190 7990 -3190 {lab=VDD}
N 7990 -3220 7990 -3190 {lab=VDD}
N 8080 -2740 8080 -2620 {lab=Vbias1}
N 8030 -2740 8080 -2740 {lab=Vbias1}
N 8080 -2890 8080 -2740 {lab=Vbias1}
N 8030 -3070 8080 -3070 {lab=Vbias1}
N 7950 -2920 7990 -2920 {lab=VDD}
N 7990 -3040 7990 -2950 {lab=#net21}
N 7950 -3070 7950 -2920 {lab=VDD}
N 8030 -2920 8080 -2920 {lab=Vbias1}
N 8080 -3070 8080 -2920 {lab=Vbias1}
N 7950 -2920 7950 -2890 {lab=VDD}
N 7990 -2890 7990 -2860 {lab=#net20}
N 8080 -2920 8080 -2890 {lab=Vbias1}
N 8080 -1860 8240 -1860 {lab=S_RST}
N 6110 -2870 6150 -2870 {lab=VDD}
N 6190 -2870 6230 -2870 {lab=Vbias1}
N 6110 -2950 6110 -2870 {lab=VDD}
N 6150 -2990 6150 -2900 {lab=#net22}
N 6110 -3020 6150 -3020 {lab=VDD}
N 6190 -3020 6230 -3020 {lab=Vbias1}
N 6110 -3100 6150 -3100 {lab=VDD}
N 6110 -3100 6110 -3020 {lab=VDD}
N 6150 -3140 6150 -3050 {lab=VDD}
N 6110 -3020 6110 -2950 {lab=VDD}
N 6230 -3020 6230 -2870 {lab=Vbias1}
N 6110 -2870 6110 -2800 {lab=VDD}
N 6230 -2870 6230 -2720 {lab=Vbias1}
N 6050 -2260 6150 -2260 {lab=ST_PULL_DOWN}
N 5810 -2260 5990 -2260 {lab=ST_PULL_DOWN2}
N 6950 -2130 7130 -2130 {lab=GND}
N 7170 -2130 7290 -2130 {lab=ST_VD1}
N 6780 -2130 6910 -2130 {lab=ST_VD2}
N 7220 -2220 7220 -2130 {lab=ST_VD1}
N 7220 -2220 7330 -2220 {lab=ST_VD1}
N 7330 -2220 7330 -2160 {lab=ST_VD1}
N 7220 -2400 7220 -2220 {lab=ST_VD1}
N 6840 -2220 6840 -2130 {lab=ST_VD2}
N 6740 -2220 6840 -2220 {lab=ST_VD2}
N 6740 -2220 6740 -2160 {lab=ST_VD2}
N 7520 -2290 7590 -2290 {lab=GND}
N 7520 -2260 7520 -2030 {lab=GND}
N 7400 -2030 7520 -2030 {lab=GND}
N 7590 -2290 7590 -2210 {lab=GND}
N 7520 -2210 7590 -2210 {lab=GND}
N 6490 -2290 6560 -2290 {lab=GND}
N 6560 -2260 6560 -2030 {lab=GND}
N 6560 -2030 6670 -2030 {lab=GND}
N 6490 -2290 6490 -2210 {lab=GND}
N 6490 -2210 6560 -2210 {lab=GND}
N 6600 -2290 6840 -2290 {lab=ST_VD2}
N 7220 -2290 7480 -2290 {lab=ST_VD1}
N 7520 -3030 7520 -2320 {lab=ST_AMP_MIR}
N 7520 -3180 7520 -3090 {lab=VDD}
N 7520 -3060 7590 -3060 {lab=VDD}
N 7590 -3140 7590 -3060 {lab=VDD}
N 7520 -3140 7590 -3140 {lab=VDD}
N 6560 -3030 6560 -2320 {lab=ST_AMP_OUT}
N 6560 -3180 6560 -3090 {lab=VDD}
N 6490 -3060 6560 -3060 {lab=VDD}
N 6490 -3140 6490 -3060 {lab=VDD}
N 6490 -3140 6560 -3140 {lab=VDD}
N 6600 -3060 7480 -3060 {lab=ST_AMP_MIR}
N 7420 -3060 7420 -2970 {lab=ST_AMP_MIR}
N 7420 -2970 7520 -2970 {lab=ST_AMP_MIR}
N 6950 -2100 6950 -2030 {lab=GND}
N 7130 -2100 7130 -2030 {lab=GND}
N 7040 -2130 7040 -2030 {lab=GND}
N 6840 -2400 6840 -2220 {lab=ST_VD2}
N 6840 -2220 6890 -2220 {lab=ST_VD2}
N 6890 -2220 7130 -2160 {lab=ST_VD2}
N 6950 -2160 7170 -2220 {lab=ST_VD1}
N 7170 -2220 7220 -2220 {lab=ST_VD1}
N 5500 -2260 5720 -2260 {lab=S_RST}
N 6190 -2130 6350 -2130 {lab=ST_AMP_OUT}
N 6350 -2460 6350 -2130 {lab=ST_AMP_OUT}
N 6350 -2460 6560 -2460 {lab=ST_AMP_OUT}
N 6150 -2030 6560 -2030 {lab=GND}
N 8020 -2350 8020 -2280 {lab=GND}
N 7220 -4400 7220 -4330 {lab=PWM_Vp}
N 6840 -4400 6840 -4330 {lab=PWM_Vp}
N 7220 -4270 7220 -4190 {lab=PWM_VD1}
N 6840 -4270 6840 -4190 {lab=PWM_VD2}
N 6740 -3820 7330 -3820 {lab=GND}
N 7040 -3820 7040 -3790 {lab=GND}
N 7260 -4300 7320 -4300 {lab=V_SAWTOOTH}
N 6730 -4300 6800 -4300 {lab=ERR_AMP_OUT}
N 7400 -3920 7400 -3820 {lab=GND}
N 7330 -3820 7400 -3820 {lab=GND}
N 7330 -3920 7400 -3920 {lab=GND}
N 6670 -3920 6670 -3820 {lab=GND}
N 6670 -3820 6740 -3820 {lab=GND}
N 6670 -3920 6740 -3920 {lab=GND}
N 6840 -4300 7220 -4300 {lab=VDD}
N 7330 -3890 7330 -3820 {lab=GND}
N 6740 -3890 6740 -3820 {lab=GND}
N 6840 -4400 7220 -4400 {lab=PWM_Vp}
N 7030 -4480 7030 -4400 {lab=PWM_Vp}
N 6990 -4510 7030 -4510 {lab=VDD}
N 7070 -4510 7110 -4510 {lab=Vbias1}
N 7110 -4510 7210 -4510 {lab=Vbias1}
N 6990 -4510 6990 -4300 {lab=VDD}
N 6990 -4590 7030 -4590 {lab=VDD}
N 7030 -4630 7030 -4540 {lab=VDD}
N 6990 -4590 6990 -4510 {lab=VDD}
N 6950 -3920 7130 -3920 {lab=GND}
N 7170 -3920 7290 -3920 {lab=PWM_VD1}
N 6780 -3920 6910 -3920 {lab=PWM_VD2}
N 7220 -4010 7220 -3920 {lab=PWM_VD1}
N 7220 -4010 7330 -4010 {lab=PWM_VD1}
N 7330 -4010 7330 -3950 {lab=PWM_VD1}
N 7220 -4190 7220 -4010 {lab=PWM_VD1}
N 6840 -4010 6840 -3920 {lab=PWM_VD2}
N 6740 -4010 6840 -4010 {lab=PWM_VD2}
N 6740 -4010 6740 -3950 {lab=PWM_VD2}
N 7520 -4080 7590 -4080 {lab=GND}
N 7520 -4050 7520 -3820 {lab=GND}
N 7400 -3820 7520 -3820 {lab=GND}
N 7590 -4080 7590 -4000 {lab=GND}
N 7520 -4000 7590 -4000 {lab=GND}
N 6490 -4080 6560 -4080 {lab=GND}
N 6560 -4050 6560 -3820 {lab=GND}
N 6560 -3820 6670 -3820 {lab=GND}
N 6490 -4080 6490 -4000 {lab=GND}
N 6490 -4000 6560 -4000 {lab=GND}
N 6600 -4080 6840 -4080 {lab=PWM_VD2}
N 7220 -4080 7480 -4080 {lab=PWM_VD1}
N 7520 -4820 7520 -4110 {lab=PWM_AMP_MIR}
N 7520 -4970 7520 -4880 {lab=VDD}
N 7520 -4850 7590 -4850 {lab=VDD}
N 7590 -4930 7590 -4850 {lab=VDD}
N 7520 -4930 7590 -4930 {lab=VDD}
N 6560 -4820 6560 -4110 {lab=PWM_AMP_OUT}
N 6560 -4970 6560 -4880 {lab=VDD}
N 6490 -4850 6560 -4850 {lab=VDD}
N 6490 -4930 6490 -4850 {lab=VDD}
N 6490 -4930 6560 -4930 {lab=VDD}
N 6600 -4850 7480 -4850 {lab=PWM_AMP_MIR}
N 7420 -4850 7420 -4760 {lab=PWM_AMP_MIR}
N 7420 -4760 7520 -4760 {lab=PWM_AMP_MIR}
N 6950 -3890 6950 -3820 {lab=GND}
N 7130 -3890 7130 -3820 {lab=GND}
N 7040 -3920 7040 -3820 {lab=GND}
N 6840 -4190 6840 -4010 {lab=PWM_VD2}
N 6840 -4010 6890 -4010 {lab=PWM_VD2}
N 6890 -4010 7130 -3950 {lab=PWM_VD2}
N 6950 -3950 7170 -4010 {lab=PWM_VD1}
N 7170 -4010 7220 -4010 {lab=PWM_VD1}
N 6020 -3820 6560 -3820 {lab=GND}
N 6060 -3920 6280 -3920 {lab=PWM_AMP_OUT}
N 6280 -4260 6280 -3920 {lab=PWM_AMP_OUT}
N 6280 -4260 6560 -4260 {lab=PWM_AMP_OUT}
N 6840 -5770 6990 -5770 {lab=SW_IN}
N 6840 -5540 6990 -5540 {lab=S_RST}
N 7110 -5560 7260 -5560 {lab=Q_b}
N 7110 -5750 7260 -5750 {lab=Q}
N 6940 -5730 6990 -5730 {lab=Q_b}
N 6940 -5730 6940 -5700 {lab=Q_b}
N 6940 -5700 7180 -5600 {lab=Q_b}
N 7180 -5600 7180 -5560 {lab=Q_b}
N 6940 -5580 6990 -5580 {lab=Q}
N 6940 -5610 6940 -5580 {lab=Q}
N 6940 -5610 7180 -5710 {lab=Q}
N 7180 -5750 7180 -5710 {lab=Q}
N 10720 -2340 10770 -2340 {lab=SW1_INV}
N 10810 -2340 10850 -2340 {lab=SW1_INV}
N 6930 -6200 6930 -5770 {lab=SW_IN}
N 6930 -6200 7050 -6200 {lab=SW_IN}
N 7350 -6200 7480 -6200 {lab=SW_IN_delay}
N 7180 -6080 7180 -5980 {lab=GND}
N 7140 -5980 7180 -5980 {lab=GND}
N 7140 -6080 7180 -6080 {lab=GND}
N 7140 -6050 7140 -5980 {lab=GND}
N 7050 -6160 7050 -6080 {lab=SW_IN}
N 7050 -6080 7100 -6080 {lab=SW_IN}
N 7140 -6290 7140 -6110 {lab=#net23}
N 7050 -6320 7050 -6160 {lab=SW_IN}
N 7050 -6320 7100 -6320 {lab=SW_IN}
N 7180 -6390 7180 -6320 {lab=VDD}
N 7140 -6320 7180 -6320 {lab=VDD}
N 7140 -6390 7140 -6350 {lab=VDD}
N 7140 -6390 7180 -6390 {lab=VDD}
N 7140 -6440 7140 -6390 {lab=VDD}
N 7390 -6080 7390 -5980 {lab=GND}
N 7350 -5980 7390 -5980 {lab=GND}
N 7350 -6080 7390 -6080 {lab=GND}
N 7350 -6050 7350 -5980 {lab=GND}
N 7260 -6160 7260 -6080 {lab=#net23}
N 7260 -6080 7310 -6080 {lab=#net23}
N 7350 -6290 7350 -6110 {lab=SW_IN_delay}
N 7260 -6320 7260 -6160 {lab=#net23}
N 7260 -6320 7310 -6320 {lab=#net23}
N 7390 -6390 7390 -6320 {lab=VDD}
N 7350 -6320 7390 -6320 {lab=VDD}
N 7350 -6390 7350 -6350 {lab=VDD}
N 7350 -6390 7390 -6390 {lab=VDD}
N 7350 -6440 7350 -6390 {lab=VDD}
N 7140 -6200 7260 -6200 {lab=#net23}
N 10770 -2340 10810 -2340 {lab=SW1_INV}
C {devices/vsource.sym} 5200 -3950 0 0 {name=V1 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 5200 -3900 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 5200 -4000 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 5010 -4000 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 8690 -2870 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.options method=gear
.options wnflag=1
.options savecurrents

.save
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm44.msky130_fd_pr__nfet_01v8[gm]
+@m.xm44.msky130_fd_pr__nfet_01v8[vth]



.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
* .model D1N914 D(Is=168.1E-21 N=1 Rs=.1 Ikf=1 Xti=3 Eg=1.11 Cjo=4p M=.3333 Vj=.75 Fc=.5 Bv=100 Ibv=100u Tt=11.54n)
.model D1N914 D(Is=533.1E-6 N=1.95 Rs=0.00141 Cjo=1.34n M=0.333 Bv=35 Ibv=50u Tt=1.44n)


.control
  * save v(sw_in) v(v_converter_out)
  save all
  tran 50ns 1ms
  remzerovec
  write tb_buck_converter_8.raw
  set appendwrite

.endc

"
}
C {devices/vsource.sym} 7360 -2390 0 0 {name=V2 value=1.6 savecurrent=false
* 0.001 1.44 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 7360 -2360 0 0 {name=V5 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {sky130_fd_pr/nfet_01v8.sym} 6040 -3920 0 1 {name=M34
W=2
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6030 -3890 2 1 {name=r3 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 7360 -2470 0 1 {name=p22 lab=ST_V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2110 -2780 0 0 {name=M1
W=16
L=0.3
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1200 -2780 0 1 {name=M2
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 750 -2920 0 1 {name=M5
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 900 -3070 0 0 {name=M7
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2130 -2540 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 2070 -2650 0 1 {name=l2 lab=GND}
C {devices/gnd.sym} 1180 -2680 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 730 -2690 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 990 -3070 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 2260 -2780 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 730 -3250 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 1180 -3560 0 0 {name=l10 lab=VDD}
C {devices/vdd.sym} 2130 -3560 0 0 {name=l11 lab=VDD}
C {lab_pin.sym} 2130 -2710 0 1 {name=p2 sig_type=std_logic lab=V_RES}
C {lab_pin.sym} 730 -3070 0 0 {name=p3 sig_type=std_logic lab=START_UP}
C {sky130_fd_pr/pfet_01v8.sym} 750 -3150 0 1 {name=M6
W=0.5
L=20
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2110 -3460 0 0 {name=M3
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1200 -3460 0 1 {name=M4
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 2290 -2700 0 0 {name=r8 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 1790 -2600 0 0 {name=M8
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1450 -2600 0 1 {name=M9
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1810 -2500 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 1430 -2500 0 1 {name=l14 lab=GND}
C {devices/vdd.sym} 1430 -3740 0 0 {name=l16 lab=VDD}
C {devices/vdd.sym} 1810 -3740 0 0 {name=l17 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1790 -3640 0 0 {name=M10
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1450 -3640 0 1 {name=M11
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2130 -3050 0 1 {name=p1 sig_type=std_logic lab=V_REF}
C {sky130_fd_pr/nfet_01v8.sym} 2550 -2650 0 1 {name=M12
W=4
L=4
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2550 0 1 {name=l13 lab=GND}
C {devices/vdd.sym} 2530 -3280 0 1 {name=l15 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2510 -3180 0 0 {name=M13
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 4260 -3380 0 0 {name=l18 lab=VDD}
C {devices/vdd.sym} 4640 -3380 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3280 0 0 {name=M14
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3280 0 1 {name=M15
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4620 -3010 0 0 {name=M16
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4280 -3010 0 1 {name=M17
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2360 0 0 {name=M18
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4260 -2260 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4660 -2580 0 1 {name=M19
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2360 0 0 {name=M20
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4620 -2230 0 0 {name=M21
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4640 -2130 0 0 {name=l21 lab=GND}
C {devices/vdd.sym} 2870 -3280 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2850 -3180 0 0 {name=M25
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2560 0 1 {name=M27
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2890 -2360 0 1 {name=M28
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2870 -2260 0 1 {name=l25 lab=GND}
C {devices/vdd.sym} 3320 -3280 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -3180 0 0 {name=M29
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2910 0 0 {name=M30
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2560 0 0 {name=M31
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -2360 0 0 {name=M32
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3320 -2260 0 0 {name=l27 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2780 0 0 {name=M33
W=12
L=0.3
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4950 -3210 0 1 {name=p4 sig_type=std_logic lab=Vbias1}
C {lab_pin.sym} 4950 -3130 0 1 {name=p5 sig_type=std_logic lab=Vhigh}
C {lab_wire.sym} 4950 -2920 0 1 {name=p6 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 4950 -2800 0 1 {name=p7 sig_type=std_logic lab=Vncas}
C {lab_wire.sym} 3580 -2690 0 1 {name=p8 sig_type=std_logic lab=Vpcas}
C {lab_wire.sym} 2390 -3110 2 1 {name=p9 sig_type=std_logic lab=Vbiasp}
C {lab_wire.sym} 3580 -2650 2 0 {name=p12 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3580 -2490 0 1 {name=p11 sig_type=std_logic lab=Vlow}
C {lab_wire.sym} 3580 -2440 2 0 {name=p13 sig_type=std_logic lab=Vbias4}
C {lab_wire.sym} 4410 -2360 2 1 {name=p14 sig_type=std_logic lab=Vbias3}
C {lab_wire.sym} 3320 -3060 0 0 {name=p16 sig_type=std_logic lab=Vds2}
C {lab_wire.sym} 3210 -3060 0 0 {name=p17 sig_type=std_logic lab=Vgs2}
C {lab_wire.sym} 3320 -2460 0 0 {name=p18 sig_type=std_logic lab=Vds3}
C {lab_wire.sym} 1430 -3320 2 0 {name=p20 sig_type=std_logic lab=Vbiasp_MIR}
C {lab_wire.sym} 1290 -2870 2 0 {name=p21 sig_type=std_logic lab=V_REF_MIR}
C {sky130_fd_pr/nfet_01v8.sym} 4240 -2570 0 0 {name=M22
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3930 -2920 0 1 {name=M23
W=12
L=1.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2360 0 0 {name=M24
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3910 -2260 0 0 {name=l22 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3890 -2570 0 0 {name=M26
W=4
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3910 -3020 0 0 {name=l24 lab=VDD}
C {lab_wire.sym} 3110 -2910 0 0 {name=p10 sig_type=std_logic lab=Vbias2}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2300 -3290 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=4 spiceprefix=X}
C {devices/vdd.sym} 2300 -3410 0 1 {name=l28 lab=VDD}
C {sky130_fd_pr/res_high_po_0p35.sym} 2130 -2650 0 0 {name=R1
L=10
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -3720 0 1 {name=M37
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
value=1110}
C {devices/gnd.sym} 9420 -3620 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -3860 0 1 {name=M44
W=12
L=0.3
nf=4 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
value=1110}
C {sky130_fd_pr/nfet_01v8.sym} 9620 -4040 0 1 {name=M45
W=12
L=0.3
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9200 -4040 0 0 {name=M46
W=12
L=0.3
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9580 -4200 0 0 {name=M47
W=12
L=0.3
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9240 -4200 0 1 {name=M48
W=12
L=0.3
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9600 -4680 0 1 {name=l31 lab=VDD}
C {devices/vdd.sym} 9220 -4680 0 1 {name=l32 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 9240 -4580 0 1 {name=M50
W=12
L=0.3
nf=1
mult=12
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9580 -4580 0 0 {name=M51
W=12
L=0.3
nf=1
mult=12
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9240 -4440 0 1 {name=M53
W=12
L=0.3
nf=1
mult=12
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9580 -4440 0 0 {name=M54
W=12
L=0.3
nf=1
mult=12
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9140 -4200 0 1 {name=l35 lab=GND}
C {devices/gnd.sym} 9680 -4200 0 0 {name=l37 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 9440 -4110 0 1 {name=M55
W=1
L=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9370 -4650 0 1 {name=M56
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9370 -4340 0 1 {name=M57
W=12
L=0.3
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 9350 -4750 0 1 {name=l38 lab=VDD}
C {lab_wire.sym} 9470 -4650 0 1 {name=p27 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 9410 -4440 0 1 {name=p32 sig_type=std_logic lab=Vbias2}
C {lab_wire.sym} 9590 -3860 2 0 {name=p33 sig_type=std_logic lab=Vbias3
value=1110}
C {lab_wire.sym} 9590 -3720 2 0 {name=p35 sig_type=std_logic lab=Vbias4
value=1110}
C {lab_pin.sym} 9600 -4340 0 1 {name=p38 lab=ERR_AMP_AMP_MIR}
C {lab_wire.sym} 9450 -3950 0 1 {name=p39 sig_type=std_logic lab=ERR_AMP_Vp}
C {lab_wire.sym} 9460 -4200 0 1 {name=p40 sig_type=std_logic lab=ERR_AMP_Vb1}
C {devices/ngspice_get_value.sym} 9440 -3680 2 1 {name=r5 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="
value=1110}
C {devices/ngspice_get_value.sym} 9440 -3820 2 1 {name=r6 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vth])
descr="vth="
value=1110}
C {devices/ngspice_get_value.sym} 9620 -4000 2 1 {name=r15 node=v(@m.xm36.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9190 -4000 2 0 {name=r16 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9440 -4080 2 1 {name=r17 node=v(@m.xm44.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4170 2 0 {name=r19 node=v(@m.xm38.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4170 2 1 {name=r20 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9370 -4300 2 1 {name=r21 node=v(@m.xm46.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4410 2 0 {name=r22 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4410 2 1 {name=r23 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9580 -4540 2 0 {name=r24 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9240 -4540 2 1 {name=r25 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9370 -4620 2 1 {name=r26 node=v(@m.xm45.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 9360 -3820 2 0 {name=r29 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3780 2 0 {name=r30 node=v(@m.xm35.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3690 2 0 {name=r31 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vdss])
descr="vdss="
value=1110}
C {devices/ngspice_get_value.sym} 9360 -3650 2 0 {name=r32 node=v(@m.xm34.msky130_fd_pr__nfet_01v8[vsat])
descr="vsat="}
C {lab_wire.sym} 9420 -3780 2 0 {name=p41 sig_type=std_logic lab=ERR_V_tail_btw
value=1110}
C {lab_wire.sym} 9600 -4130 0 1 {name=p42 sig_type=std_logic lab=ERR_AMP_Vd1}
C {lab_wire.sym} 9220 -4130 0 0 {name=p43 sig_type=std_logic lab=ERR_AMP_Vd2}
C {lab_pin.sym} 8440 -4350 0 0 {name=p37 lab=ERR_AMP_OUT}
C {res.sym} 10320 -4230 0 0 {name=R46
value=10000
footprint=1206
device=resistor
m=1}
C {capa.sym} 8620 -4080 3 0 {name=C3
m=1
value=0.005n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 8800 -4080 3 0 {name=R47
value=16700
footprint=1206
device=resistor
m=1}
C {capa.sym} 8660 -4010 3 1 {name=C4
m=1
value=0.07n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10470 -4310 0 0 {name=R48
value=700
footprint=1206
device=resistor
m=1}
C {capa.sym} 10470 -4120 0 0 {name=C5
m=1
value=3.3n
footprint=1206
device="ceramic capacitor"}
C {res.sym} 10390 -3950 0 0 {name=R49
value=1000
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 10390 -3830 0 1 {name=l46 lab=GND
value=1110}
C {lab_pin.sym} 9930 -4040 0 1 {name=p26 lab=ERR_AMP_REF}
C {lab_wire.sym} 9070 -4040 2 1 {name=p59 sig_type=std_logic lab=ERR_AMP_VIN}
C {lab_wire.sym} 10320 -4040 2 1 {name=p60 sig_type=std_logic lab=ERR_AMP_VIN}
C {devices/vsource.sym} 10250 -3860 0 1 {name=V3 value=0.909 savecurrent=false
* 1.4 0.907 "pwl(0 0.17 2us 0.17 2us 0.12 4us 0.12 4us 0.22)"
* 1.34 1.25 "sin(1.0 0.001 200k)"}
C {devices/gnd.sym} 10250 -3830 0 1 {name=V4 value="pulse(1.241 1.239 0ns 10ns 10ns 240ns 500ns)" savecurrent=false
* * 100k)"
* "sin(1.24 -0.001 * 1.24 3us 1.24 3.01us 1.239)"}
C {lab_pin.sym} 10250 -3940 0 0 {name=p61 lab=ERR_AMP_REF}
C {lab_wire.sym} 10390 -4610 0 1 {name=p58 sig_type=std_logic lab=V_CONVERTER_OUT}
C {lab_wire.sym} 6150 -4370 0 1 {name=p31 sig_type=std_logic lab=Vbias1}
C {sky130_fd_pr/pfet_01v8.sym} 6040 -4370 0 1 {name=M52
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6030 -4340 2 1 {name=r10 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 6020 -4790 0 1 {name=l34 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 6040 -4520 0 1 {name=M82
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6030 -4490 2 1 {name=r52 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 6040 -4670 0 1 {name=M83
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6030 -4640 2 1 {name=r53 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 8530 -4160 0 1 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {ammeter.sym} 9220 -4280 0 1 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {ammeter.sym} 8710 -4080 3 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {ammeter.sym} 8770 -4010 3 1 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {lab_wire.sym} 8660 -4160 0 1 {name=p63 sig_type=std_logic lab=INT_BTW}
C {lab_wire.sym} 9600 -4510 0 1 {name=p65 sig_type=std_logic lab=ERR_AMP_Vd3}
C {lab_wire.sym} 9220 -4510 0 0 {name=p66 sig_type=std_logic lab=ERR_AMP_Vd4}
C {lab_wire.sym} 9090 -4350 0 0 {name=p67 sig_type=std_logic lab=ERR_AMP_OUT}
C {ammeter.sym} 10470 -4220 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {ammeter.sym} 10320 -4120 0 1 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/vsource.sym} 10220 -2590 0 1 {name=V12 value=25 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {res.sym} 11520 -2330 0 0 {name=R27
value=1
footprint=1206
device=resistor
m=1}
C {ind.sym} 11100 -2540 1 0 {name=L53
m=1
value=30u
footprint=1206
device=inductor}
C {capa.sym} 11320 -2230 0 0 {name=C6
m=1
value=250u
footprint=1206
device="ceramic capacitor"}
C {res.sym} 11320 -2420 0 0 {name=R28
value=0.05
footprint=1206
device=resistor
m=1}
C {gnd.sym} 10850 -2650 0 0 {name=l55 lab=GND}
C {switch_ngspice.sym} 10890 -2690 0 0 {name=S1 model=SW1
device_model=".MODEL SW1 SW( VT=0.9 VH=0.01 RON=0.01 ROFF=10G )"}
C {lab_pin.sym} 11520 -2540 2 0 {name=p68 sig_type=std_logic lab=V_CONVERTER_OUT}
C {gnd.sym} 11090 -2120 0 1 {name=l56 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5720 -3920 0 1 {name=M35
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5720 -4160 0 1 {name=M36
W=36
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5680 -4130 2 0 {name=r2 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5710 -3890 2 1 {name=r4 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 5700 -4280 0 1 {name=l33 lab=VDD}
C {lab_wire.sym} 5470 -4050 0 0 {name=p19 sig_type=std_logic lab=SW_IN}
C {lab_wire.sym} 6020 -4050 0 1 {name=p62 sig_type=std_logic lab=PMW_PULL_DOWN}
C {lab_wire.sym} 10280 -2850 0 0 {name=p23 sig_type=std_logic lab=buck_vin}
C {lab_wire.sym} 10890 -2470 0 0 {name=p69 sig_type=std_logic lab=V_DIODE}
C {gnd.sym} 10850 -2300 0 1 {name=l54 lab=GND}
C {switch_ngspice.sym} 10890 -2340 0 0 {name=S2 model=SW1
device_model=".MODEL SW1 SW( VT=0.9 VH=0.01 RON=0.01 ROFF=10G )"}
C {lab_wire.sym} 10740 -2340 0 1 {name=p54 sig_type=std_logic lab=SW1_INV}
C {vcvs.sym} 10580 -2310 0 0 {name=E1 value=-1}
C {gnd.sym} 10580 -2260 0 0 {name=l57 lab=GND}
C {gnd.sym} 10540 -2270 0 1 {name=l58 lab=GND}
C {devices/vsource.sym} 10690 -2340 1 1 {name=V6 value=1.8 savecurrent=false
* "pwl(0 0 1us 0 1.2us 1.8)"}
C {devices/gnd.sym} 7040 -2010 0 1 {name=l39 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7310 -2130 0 0 {name=M58
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6760 -2130 0 1 {name=M59
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6820 -2510 0 0 {name=M60
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7240 -2510 0 1 {name=M61
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6560 -2670 0 0 {name=p44 lab=ST_AMP_OUT}
C {lab_pin.sym} 7520 -2670 0 1 {name=p46 lab=ST_AMP_MIR}
C {devices/ngspice_get_value.sym} 7200 -2470 2 0 {name=r37 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6860 -2470 2 1 {name=r38 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 6170 -2130 0 1 {name=M64
W=2
L=0.3
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5740 -2130 0 1 {name=M65
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5740 -2370 0 1 {name=M66
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 5700 -2340 2 0 {name=r39 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6160 -2100 2 1 {name=r40 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5730 -2100 2 1 {name=r41 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 5720 -2490 0 1 {name=l40 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 7050 -2720 0 1 {name=M67
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7040 -2690 2 1 {name=r42 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7210 -2720 0 1 {name=p48 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 6150 -2260 0 1 {name=p49 sig_type=std_logic lab=ST_PULL_DOWN}
C {devices/vdd.sym} 7030 -2840 0 1 {name=l41 lab=VDD}
C {lab_wire.sym} 7110 -2610 0 1 {name=p50 sig_type=std_logic lab=ST_Vp}
C {sky130_fd_pr/pfet_01v8.sym} 6170 -2720 0 1 {name=M68
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6160 -2690 2 1 {name=r43 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 6280 -2720 0 1 {name=p51 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 6150 -3140 0 1 {name=l42 lab=VDD}
C {lab_pin.sym} 6840 -2430 0 0 {name=p52 lab=ST_VD2}
C {lab_pin.sym} 7220 -2430 0 1 {name=p53 lab=ST_VD1}
C {lab_pin.sym} 7320 -2510 0 1 {name=p55 lab=ST_V_REF}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7870 -2350 0 1 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=290 spiceprefix=X}
C {devices/gnd.sym} 7870 -2230 0 1 {name=l43 lab=GND}
C {devices/ngspice_get_value.sym} 8120 -2320 2 1 {name=r44 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 7870 -2450 0 1 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 8130 -2350 0 1 {name=M69
W=8
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8240 -2350 0 1 {name=p57 sig_type=std_logic lab=S_RST}
C {lab_wire.sym} 7690 -2510 2 1 {name=p47 sig_type=std_logic lab=V_SAWTOOTH}
C {sky130_fd_pr/pfet_01v8.sym} 8010 -2620 0 1 {name=M70
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 8000 -2590 2 1 {name=r45 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 8170 -2620 0 1 {name=p56 sig_type=std_logic lab=Vbias1}
C {lab_wire.sym} 7770 -2930 0 1 {name=p64 sig_type=std_logic lab=V_SAWTOOTH}
C {sky130_fd_pr/pfet_01v8.sym} 8010 -2740 0 1 {name=M62
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8010 -3070 0 1 {name=M63
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7990 -3220 0 1 {name=l44 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 8010 -2920 0 1 {name=M71
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 5840 -2260 0 1 {name=p70 sig_type=std_logic lab=ST_PULL_DOWN2}
C {sky130_fd_pr/pfet_01v8.sym} 6170 -2870 0 1 {name=M72
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6160 -2840 2 1 {name=r33 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 6170 -3020 0 1 {name=M73
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 6160 -2990 2 1 {name=r34 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {ammeter.sym} 6020 -2260 3 1 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 7500 -2290 0 0 {name=M74
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6580 -2290 0 1 {name=M75
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7500 -3060 0 0 {name=M76
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6580 -3060 0 1 {name=M77
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7520 -3180 0 1 {name=l45 lab=VDD}
C {devices/vdd.sym} 6560 -3180 0 1 {name=l47 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 7150 -2130 0 1 {name=M78
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6930 -2130 0 0 {name=M79
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6730 -2510 2 1 {name=p71 sig_type=std_logic lab=V_SAWTOOTH}
C {devices/gnd.sym} 7040 -3800 0 1 {name=l48 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7310 -3920 0 0 {name=M80
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6760 -3920 0 1 {name=M81
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6820 -4300 0 0 {name=M84
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7240 -4300 0 1 {name=M85
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6560 -4460 0 0 {name=p73 lab=PWM_AMP_OUT}
C {lab_pin.sym} 7520 -4460 0 1 {name=p74 lab=PWM_AMP_MIR}
C {devices/ngspice_get_value.sym} 7200 -4260 2 0 {name=r35 node=v(@m.xm41.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6860 -4260 2 1 {name=r36 node=v(@m.xm40.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 7050 -4510 0 1 {name=M86
W=12
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7040 -4480 2 1 {name=r50 node=v(@m.xm14.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 7210 -4510 0 1 {name=p75 sig_type=std_logic lab=Vbias1}
C {devices/vdd.sym} 7030 -4630 0 1 {name=l49 lab=VDD}
C {lab_wire.sym} 7110 -4400 0 1 {name=p76 sig_type=std_logic lab=PWM_Vp}
C {lab_pin.sym} 6840 -4220 0 0 {name=p77 lab=PWM_VD2}
C {lab_pin.sym} 7220 -4220 0 1 {name=p78 lab=PWM_VD1}
C {sky130_fd_pr/nfet_01v8.sym} 7500 -4080 0 0 {name=M87
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6580 -4080 0 1 {name=M88
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7500 -4850 0 0 {name=M89
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6580 -4850 0 1 {name=M90
W=12
L=0.15
nf=6
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 7520 -4970 0 1 {name=l50 lab=VDD}
C {devices/vdd.sym} 6560 -4970 0 1 {name=l51 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 7150 -3920 0 1 {name=M91
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6930 -3920 0 0 {name=M92
W=4
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 7320 -4300 2 0 {name=p80 sig_type=std_logic lab=V_SAWTOOTH}
C {lab_pin.sym} 6730 -4300 0 0 {name=p72 lab=ERR_AMP_OUT}
C {lab_pin.sym} 11320 -2330 2 1 {name=p15 sig_type=std_logic lab=V_CAP}
C {lab_wire.sym} 6840 -5540 2 1 {name=p82 sig_type=std_logic lab=S_RST}
C {lab_wire.sym} 6840 -5770 0 0 {name=p83 sig_type=std_logic lab=SW_IN}
C {devices/lab_pin.sym} 7260 -5750 0 1 {name=p84 sig_type=std_logic lab=Q}
C {devices/lab_pin.sym} 7260 -5560 0 1 {name=p85 sig_type=std_logic lab=Q_b}
C {nand_pfd.sym} 7050 -5750 0 0 {name=x3}
C {nand_pfd.sym} 7050 -5560 0 0 {name=x1}
C {devices/vdd.sym} 7050 -5800 0 1 {name=l29 lab=VDD}
C {devices/vdd.sym} 7050 -5610 0 1 {name=l36 lab=VDD}
C {devices/gnd.sym} 7050 -5700 0 1 {name=l52 lab=GND}
C {devices/gnd.sym} 7050 -5510 0 1 {name=l59 lab=GND}
C {lab_wire.sym} 7480 -6200 0 1 {name=p24 sig_type=std_logic lab=SW_IN_delay}
C {lab_wire.sym} 10370 -2690 0 0 {name=p25 sig_type=std_logic lab=SW_IN_delay}
C {sky130_fd_pr/nfet_01v8.sym} 7120 -6080 0 0 {name=M38
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7120 -6320 0 0 {name=M39
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7160 -6290 2 1 {name=r7 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7130 -6050 2 0 {name=r9 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 7140 -6440 0 0 {name=l60 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 7330 -6080 0 0 {name=M40
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7330 -6320 0 0 {name=M41
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 7370 -6290 2 1 {name=r11 node=v(@m.xm42.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 7340 -6050 2 0 {name=r12 node=v(@m.xm39.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 7350 -6440 0 0 {name=l61 lab=VDD}
C {devices/gnd.sym} 7140 -5980 0 1 {name=l62 lab=GND}
C {devices/gnd.sym} 7350 -5980 0 1 {name=l63 lab=GND}
