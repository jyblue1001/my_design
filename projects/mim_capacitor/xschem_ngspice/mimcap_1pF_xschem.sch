v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_1.sym} 120 -80 0 0 {name=C1 model=cap_mim_m3_1 W=25 L=20 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 120 -110 2 1 {name=p1 sig_type=std_logic lab=top}
C {devices/lab_pin.sym} 120 -50 0 0 {name=p4 sig_type=std_logic lab=bot}
