v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {N 30uA} 13770 -2810 0 0 1 1 {}
T {P 30uA} 13790 -3500 0 0 1 1 {}
T {P 30uA} 15890 -3500 0 1 1 1 {}
T {N 30uA} 15910 -2810 0 1 1 1 {}
T {1st stage pmos current source load voltage bias references} 1090 -4110 0 0 2 2 {}
T {1st stage} 9130 -4540 0 0 4 4 {}
T {1st gain stage} 8080 -3840 0 0 2 2 {}
T {1st stage CMFB} 12670 -3920 0 0 2 2 {}
T {2nd stage} 18110 -4340 0 0 4 4 {}
N 8040 -1770 8040 -1680 {lab=V_p}
N 8040 -1680 8790 -1680 {lab=V_p}
N 8790 -1770 8790 -1680 {lab=V_p}
N 8040 -2380 8040 -1830 {lab=VD1}
N 8790 -2380 8790 -1830 {lab=VD2}
N 8080 -2410 8750 -2410 {lab=Vb1}
N 8040 -2740 8040 -2440 {lab=X}
N 8790 -2740 8790 -2440 {lab=Y}
N 8040 -3160 8040 -2800 {lab=VD3}
N 8790 -3160 8790 -2800 {lab=VD4}
N 8080 -2770 8750 -2770 {lab=Vb2}
N 8790 -2770 8860 -2770 {lab=VD4}
N 8860 -2840 8860 -2770 {lab=VD4}
N 8790 -2840 8860 -2840 {lab=VD4}
N 7970 -2770 8040 -2770 {lab=VD3}
N 7970 -2840 7970 -2770 {lab=VD3}
N 7970 -2840 8040 -2840 {lab=VD3}
N 8040 -3340 8040 -3220 {lab=VDDA}
N 8790 -3340 8790 -3220 {lab=VDDA}
N 8080 -3190 8750 -3190 {lab=Vb3}
N 8790 -3190 8860 -3190 {lab=VDDA}
N 8860 -3260 8860 -3190 {lab=VDDA}
N 8790 -3260 8860 -3260 {lab=VDDA}
N 7970 -3190 8040 -3190 {lab=VDDA}
N 7970 -3260 7970 -3190 {lab=VDDA}
N 7970 -3260 8040 -3260 {lab=VDDA}
N 8040 -3340 8790 -3340 {lab=VDDA}
N 7990 -2410 8040 -2410 {lab=GNDA}
N 7990 -2410 7990 -2350 {lab=GNDA}
N 7990 -2350 8850 -2350 {lab=GNDA}
N 8850 -2410 8850 -2350 {lab=GNDA}
N 8790 -2410 8850 -2410 {lab=GNDA}
N 8220 -3400 8220 -3340 {lab=VDDA}
N 8490 -1800 8790 -1800 {lab=GNDA}
N 8040 -1800 8490 -1800 {lab=GNDA}
N 8340 -1680 8340 -1570 {lab=V_p}
N 8490 -1800 8490 -1540 {lab=GNDA}
N 8340 -1540 8490 -1540 {lab=GNDA}
N 8340 -1510 8340 -1020 {lab=GNDA}
N 8340 -1460 8490 -1460 {lab=GNDA}
N 8490 -1540 8490 -1460 {lab=GNDA}
N 8830 -1800 8920 -1800 {lab=VIN+}
N 6230 -1680 6230 -1570 {lab=V_p_mir}
N 6150 -1540 6230 -1540 {lab=GNDA}
N 6230 -1510 6230 -1300 {lab=GNDA}
N 6150 -1460 6230 -1460 {lab=GNDA}
N 6150 -1540 6150 -1460 {lab=GNDA}
N 6270 -1540 8300 -1540 {lab=V_tail_gate}
N 6310 -1800 6400 -1800 {lab=GNDA}
N 6070 -1800 6310 -1800 {lab=GNDA}
N 6070 -1770 6070 -1680 {lab=V_p_mir}
N 6070 -1680 6400 -1680 {lab=V_p_mir}
N 6400 -1770 6400 -1680 {lab=V_p_mir}
N 6150 -1800 6150 -1540 {lab=GNDA}
N 6070 -1950 6070 -1830 {lab=V_tail_gate}
N 6070 -1950 6400 -1950 {lab=V_tail_gate}
N 6400 -1950 6400 -1830 {lab=V_tail_gate}
N 6230 -2150 6230 -1950 {lab=V_tail_gate}
N 6440 -1800 6510 -1800 {lab=VIN-}
N 5960 -1800 6030 -1800 {lab=VIN+}
N 6230 -2070 6800 -2070 {lab=V_tail_gate}
N 6800 -2070 6800 -1540 {lab=V_tail_gate}
N 8340 -1970 8340 -1680 {lab=V_p}
N 8340 -2980 8340 -2410 {lab=Vb1}
N 14060 -3030 14060 -2980 {lab=VDDA}
N 14060 -2820 14060 -2760 {lab=GNDA}
N 14060 -2920 14060 -2880 {lab=V_CMFB_S2}
N 14060 -3260 14060 -3210 {lab=GNDA}
N 14060 -3370 14060 -3320 {lab=V_CMFB_S1}
N 13940 -3290 13940 -2950 {lab=X}
N 15660 -3290 15750 -3290 {lab=Y}
N 15750 -3290 15750 -2950 {lab=Y}
N 15660 -2950 15750 -2950 {lab=Y}
N 13820 -3130 13940 -3130 {lab=X}
N 15750 -3130 15870 -3130 {lab=Y}
N 14990 -3340 15620 -3340 {lab=V_CMFB_S3}
N 14990 -2900 15620 -2900 {lab=V_CMFB_S4}
N 14060 -3290 14140 -3290 {lab=VDDA}
N 14060 -3450 14140 -3450 {lab=VDDA}
N 14060 -3500 14060 -3420 {lab=VDDA}
N 14140 -3450 14140 -3290 {lab=VDDA}
N 14060 -2790 14140 -2790 {lab=GNDA}
N 14060 -2950 14140 -2950 {lab=GNDA}
N 14140 -2950 14140 -2790 {lab=GNDA}
N 15620 -3030 15620 -2980 {lab=VDDA}
N 15620 -2820 15620 -2760 {lab=GNDA}
N 15620 -2920 15620 -2880 {lab=V_CMFB_S4}
N 15620 -3260 15620 -3210 {lab=GNDA}
N 15620 -3370 15620 -3320 {lab=V_CMFB_S3}
N 15540 -3290 15620 -3290 {lab=VDDA}
N 15540 -3450 15620 -3450 {lab=VDDA}
N 15620 -3500 15620 -3420 {lab=VDDA}
N 15540 -3450 15540 -3290 {lab=VDDA}
N 15540 -2790 15620 -2790 {lab=GNDA}
N 15540 -2950 15620 -2950 {lab=GNDA}
N 15540 -2950 15540 -2790 {lab=GNDA}
N 14830 -3340 14830 -2900 {lab=V_tot}
N 12800 -2330 12800 -2260 {lab=V_err_p}
N 12560 -2330 12800 -2330 {lab=V_err_p}
N 12560 -2330 12560 -2260 {lab=V_err_p}
N 12680 -2590 12680 -2330 {lab=V_err_p}
N 12680 -2900 12680 -2650 {lab=VDDA}
N 12800 -2200 12800 -1340 {lab=err_amp_mir}
N 12560 -2200 12560 -1340 {lab=err_amp_out}
N 12800 -1280 12800 -1200 {lab=GNDA}
N 12560 -1200 12800 -1200 {lab=GNDA}
N 12560 -1280 12560 -1200 {lab=GNDA}
N 12680 -1200 12680 -1150 {lab=GNDA}
N 12560 -2230 12800 -2230 {lab=VDDA}
N 12600 -1310 12760 -1310 {lab=err_amp_mir}
N 12520 -1310 12560 -1310 {lab=GNDA}
N 12520 -1310 12520 -1260 {lab=GNDA}
N 12520 -1260 12560 -1260 {lab=GNDA}
N 12800 -1310 12840 -1310 {lab=GNDA}
N 12840 -1310 12840 -1260 {lab=GNDA}
N 12800 -1260 12840 -1260 {lab=GNDA}
N 12700 -1390 12800 -1390 {lab=err_amp_mir}
N 12700 -1390 12700 -1310 {lab=err_amp_mir}
N 14830 -2900 14830 -2230 {lab=V_tot}
N 12430 -2230 12520 -2230 {lab=V_err_amp_ref}
N 8490 -1540 8640 -1540 {lab=GNDA}
N 8490 -1460 8640 -1460 {lab=GNDA}
N 8640 -1510 8640 -1460 {lab=GNDA}
N 8640 -1680 8640 -1570 {lab=V_p}
N 12840 -2230 14830 -2230 {lab=V_tot}
N 12680 -2620 12720 -2620 {lab=VDDA}
N 12720 -2680 12720 -2620 {lab=VDDA}
N 12680 -2680 12720 -2680 {lab=VDDA}
N 12720 -2620 12720 -2230 {lab=VDDA}
N 11260 -2500 11260 -2430 {lab=V_err_mir_p}
N 11260 -2500 11500 -2500 {lab=V_err_mir_p}
N 11500 -2500 11500 -2430 {lab=V_err_mir_p}
N 11380 -2590 11380 -2500 {lab=V_err_mir_p}
N 11380 -2900 11380 -2650 {lab=VDDA}
N 11260 -2400 11500 -2400 {lab=VDDA}
N 11540 -2400 11630 -2400 {lab=V_err_amp_ref}
N 11340 -2620 11380 -2620 {lab=VDDA}
N 11340 -2680 11340 -2620 {lab=VDDA}
N 11340 -2680 11380 -2680 {lab=VDDA}
N 11340 -2620 11340 -2400 {lab=VDDA}
N 11420 -2620 12640 -2620 {lab=V_err_gate}
N 11260 -2370 11260 -2310 {lab=V_err_gate}
N 11260 -2310 11500 -2310 {lab=V_err_gate}
N 11500 -2370 11500 -2310 {lab=V_err_gate}
N 11380 -2310 11380 -2070 {lab=V_err_gate}
N 11130 -2400 11220 -2400 {lab=V_tot}
N 11830 -2620 11830 -2250 {lab=V_err_gate}
N 11380 -2250 11830 -2250 {lab=V_err_gate}
N 8680 -1540 12410 -1540 {lab=err_amp_out}
N 12410 -1540 12560 -1540 {lab=err_amp_out}
N 18130 -2860 18130 -2220 {lab=VOUT-}
N 19200 -2860 19200 -2220 {lab=VOUT+}
N 19200 -2890 19270 -2890 {lab=VDDA}
N 19270 -2960 19270 -2890 {lab=VDDA}
N 19200 -2960 19270 -2960 {lab=VDDA}
N 18060 -2890 18130 -2890 {lab=VDDA}
N 18060 -2960 18130 -2960 {lab=VDDA}
N 18060 -2960 18060 -2890 {lab=VDDA}
N 18130 -3040 18130 -2920 {lab=VDDA}
N 19200 -3040 19200 -2920 {lab=VDDA}
N 18130 -2160 18130 -1990 {lab=GNDA}
N 19200 -2160 19200 -1990 {lab=GNDA}
N 19200 -2120 19270 -2120 {lab=GNDA}
N 19270 -2190 19270 -2120 {lab=GNDA}
N 19200 -2190 19270 -2190 {lab=GNDA}
N 18060 -2120 18130 -2120 {lab=GNDA}
N 18060 -2190 18130 -2190 {lab=GNDA}
N 18060 -2190 18060 -2120 {lab=GNDA}
N 18170 -2890 18500 -2890 {lab=X}
N 18830 -2890 19160 -2890 {lab=Y}
N 17890 -2500 18130 -2500 {lab=VOUT-}
N 19200 -2500 19450 -2500 {lab=VOUT+}
N 19070 -2310 19200 -2310 {lab=VOUT+}
N 18670 -2190 19160 -2190 {lab=V_b_2nd_stage}
N 18730 -2310 19010 -2310 {lab=V_b_2nd_stage}
N 18730 -2310 18730 -2190 {lab=V_b_2nd_stage}
N 18130 -2310 18260 -2310 {lab=VOUT-}
N 18320 -2310 18610 -2310 {lab=V_b_2nd_stage}
N 18170 -2190 18670 -2190 {lab=V_b_2nd_stage}
N 18610 -2310 18610 -2190 {lab=V_b_2nd_stage}
N 14730 -2900 14930 -2900 {lab=V_tot}
N 14730 -3340 14930 -3340 {lab=V_tot}
N 14060 -3340 14670 -3340 {lab=V_CMFB_S1}
N 14060 -2900 14670 -2900 {lab=V_CMFB_S2}
N 13940 -3290 14020 -3290 {lab=X}
N 13940 -2950 14020 -2950 {lab=X}
N 7870 -1800 8000 -1800 {lab=VIN-}
N 15620 -2900 15740 -2900 {lab=V_CMFB_S4}
N 15620 -3340 15730 -3340 {lab=V_CMFB_S3}
N 8040 -1680 8790 -1680 {lab=V_p}
N 7060 -1800 7870 -1800 {lab=VIN-}
N 6510 -1800 7060 -1800 {lab=VIN-}
N 5960 -1900 7060 -1900 {lab=VIN+}
N 5960 -1900 5960 -1800 {lab=VIN+}
N 8920 -1900 8920 -1800 {lab=VIN+}
N 7060 -1900 8920 -1900 {lab=VIN+}
N 7870 -1740 7870 -1670 {lab=VIN-}
N 8920 -1740 8920 -1670 {lab=VIN+}
N 6230 -2340 6230 -2150 {lab=V_tail_gate}
N 13940 -2900 14060 -2900 {lab=V_CMFB_S2}
N 13940 -3340 14060 -3340 {lab=V_CMFB_S1}
N 7870 -1800 7870 -1740 {lab=VIN-}
N 8920 -1800 8920 -1740 {lab=VIN+}
N 18880 -2890 18880 -2810 {lab=Y}
N 18450 -2890 18450 -2810 {lab=X}
N 19060 -2660 19200 -2660 {lab=VOUT+}
N 18130 -2660 18270 -2660 {lab=VOUT-}
N 18880 -2750 18880 -2660 {lab=cap_res_Y}
N 18450 -2750 18450 -2660 {lab=cap_res_X}
N 18330 -2660 18450 -2660 {lab=cap_res_X}
N 18880 -2660 19000 -2660 {lab=cap_res_Y}
N 6400 -1370 6400 -1340 {lab=GNDA}
N 6320 -1400 6400 -1400 {lab=GNDA}
N 6320 -1400 6320 -1340 {lab=GNDA}
N 6230 -1340 6400 -1340 {lab=GNDA}
N 6230 -1460 6400 -1460 {lab=GNDA}
N 6440 -1400 6480 -1400 {lab=GNDA}
N 6480 -1400 6480 -1340 {lab=GNDA}
N 6400 -1340 6480 -1340 {lab=GNDA}
N 8840 -1270 8840 -1110 {lab=GNDA}
N 8740 -1300 8840 -1300 {lab=GNDA}
N 8740 -1300 8740 -1110 {lab=GNDA}
N 8880 -1300 8960 -1300 {lab=GNDA}
N 8960 -1300 8960 -1110 {lab=GNDA}
N 8840 -1630 8840 -1330 {lab=V_p}
N 8640 -1630 8840 -1630 {lab=V_p}
N 5610 -1800 5740 -1800 {lab=GNDA}
N 5610 -1950 5610 -1830 {lab=V_tail_gate}
N 5610 -1950 6070 -1950 {lab=V_tail_gate}
N 5470 -1800 5570 -1800 {lab=GNDA}
N 5470 -1800 5470 -1710 {lab=GNDA}
N 5470 -1710 5610 -1710 {lab=GNDA}
N 5610 -1540 6150 -1540 {lab=GNDA}
N 5610 -1770 5610 -1540 {lab=GNDA}
N 5740 -1800 5740 -1540 {lab=GNDA}
N 7390 -1300 7460 -1300 {lab=GNDA}
N 7390 -1300 7390 -1210 {lab=GNDA}
N 7390 -1210 7500 -1210 {lab=GNDA}
N 7500 -2000 7500 -1330 {lab=VD1}
N 9370 -1300 9440 -1300 {lab=GNDA}
N 9440 -1300 9440 -1210 {lab=GNDA}
N 9330 -1210 9440 -1210 {lab=GNDA}
N 9330 -2000 9330 -1330 {lab=VD2}
N 7500 -1270 7500 -1110 {lab=GNDA}
N 9330 -1270 9330 -1110 {lab=GNDA}
N 8960 -1110 9330 -1110 {lab=GNDA}
N 8790 -2000 9330 -2000 {lab=VD2}
N 7500 -2000 8040 -2000 {lab=VD1}
N 7500 -1110 8340 -1110 {lab=GNDA}
N 9170 -2410 9240 -2410 {lab=GNDA}
N 9240 -2410 9240 -2320 {lab=GNDA}
N 9130 -2320 9240 -2320 {lab=GNDA}
N 9130 -2380 9130 -2230 {lab=GNDA}
N 9130 -2530 9130 -2440 {lab=Y}
N 8790 -2530 9130 -2530 {lab=Y}
N 9025 -2410 9130 -2410 {lab=GNDA}
N 9025 -2410 9025 -2320 {lab=GNDA}
N 9025 -2320 9130 -2320 {lab=GNDA}
N 7700 -3190 7830 -3190 {lab=VDDA}
N 7830 -3280 7830 -3190 {lab=VDDA}
N 7700 -3280 7830 -3280 {lab=VDDA}
N 7700 -3280 7700 -3220 {lab=VDDA}
N 7570 -3280 7570 -3190 {lab=VDDA}
N 7570 -3280 7700 -3280 {lab=VDDA}
N 7570 -3190 7660 -3190 {lab=VDDA}
N 7700 -3340 8040 -3340 {lab=VDDA}
N 7700 -3340 7700 -3280 {lab=VDDA}
N 7700 -3160 7700 -3100 {lab=VD3}
N 7700 -3100 8040 -3100 {lab=VD3}
N 9000 -2770 9130 -2770 {lab=VD4}
N 9000 -2860 9000 -2770 {lab=VD4}
N 9000 -2860 9130 -2860 {lab=VD4}
N 9130 -2860 9130 -2800 {lab=VD4}
N 9260 -2860 9260 -2770 {lab=VD4}
N 9130 -2860 9260 -2860 {lab=VD4}
N 9170 -2770 9260 -2770 {lab=VD4}
N 8790 -2920 9130 -2920 {lab=VD4}
N 9130 -2920 9130 -2860 {lab=VD4}
N 9130 -2740 9130 -2680 {lab=Y}
N 8790 -2680 9130 -2680 {lab=Y}
N 7700 -2770 7830 -2770 {lab=VD3}
N 7830 -2860 7830 -2770 {lab=VD3}
N 7700 -2860 7830 -2860 {lab=VD3}
N 7700 -2860 7700 -2800 {lab=VD3}
N 7570 -2860 7570 -2770 {lab=VD3}
N 7570 -2860 7700 -2860 {lab=VD3}
N 7570 -2770 7660 -2770 {lab=VD3}
N 7700 -2920 8040 -2920 {lab=VD3}
N 7700 -2920 7700 -2860 {lab=VD3}
N 7700 -2740 7700 -2680 {lab=X}
N 7700 -2680 8040 -2680 {lab=X}
N 12160 -1900 12230 -1900 {lab=VDDA}
N 12160 -1990 12160 -1900 {lab=VDDA}
N 12160 -1990 12270 -1990 {lab=VDDA}
N 12270 -1990 12270 -1930 {lab=VDDA}
N 12270 -1990 12380 -1990 {lab=VDDA}
N 12380 -1990 12380 -1900 {lab=VDDA}
N 12270 -1900 12380 -1900 {lab=VDDA}
N 12270 -1870 12270 -1820 {lab=err_amp_out}
N 12270 -2030 12270 -1990 {lab=VDDA}
N 10780 -2400 10850 -2400 {lab=VDDA}
N 10780 -2490 10780 -2400 {lab=VDDA}
N 10780 -2490 10890 -2490 {lab=VDDA}
N 10890 -2490 10890 -2430 {lab=VDDA}
N 10890 -2490 11000 -2490 {lab=VDDA}
N 11000 -2490 11000 -2400 {lab=VDDA}
N 10890 -2400 11000 -2400 {lab=VDDA}
N 10890 -2530 10890 -2490 {lab=VDDA}
N 10890 -2310 11260 -2310 {lab=V_err_gate}
N 10890 -2370 10890 -2310 {lab=V_err_gate}
N 12270 -1820 12560 -1820 {lab=err_amp_out}
N 13130 -1900 13200 -1900 {lab=VDDA}
N 13200 -1990 13200 -1900 {lab=VDDA}
N 13090 -1990 13200 -1990 {lab=VDDA}
N 13090 -1990 13090 -1930 {lab=VDDA}
N 12980 -1990 13090 -1990 {lab=VDDA}
N 12980 -1990 12980 -1900 {lab=VDDA}
N 12980 -1900 13090 -1900 {lab=VDDA}
N 13090 -1870 13090 -1820 {lab=err_amp_mir}
N 13090 -2030 13090 -1990 {lab=VDDA}
N 12800 -1820 13090 -1820 {lab=err_amp_mir}
N 14300 -3390 14390 -3390 {lab=VDDA}
N 14430 -3390 14480 -3390 {lab=VDDA}
N 14140 -3450 14390 -3450 {lab=VDDA}
N 14390 -3450 14390 -3420 {lab=VDDA}
N 14480 -3450 14480 -3390 {lab=VDDA}
N 14390 -3450 14480 -3450 {lab=VDDA}
N 14300 -3450 14300 -3390 {lab=VDDA}
N 14390 -3360 14390 -3240 {lab=GNDA}
N 14060 -3240 14390 -3240 {lab=GNDA}
N 15270 -3390 15360 -3390 {lab=VDDA}
N 15180 -3390 15230 -3390 {lab=VDDA}
N 15270 -3450 15540 -3450 {lab=VDDA}
N 15270 -3450 15270 -3420 {lab=VDDA}
N 15180 -3450 15180 -3390 {lab=VDDA}
N 15180 -3450 15270 -3450 {lab=VDDA}
N 15360 -3450 15360 -3390 {lab=VDDA}
N 15270 -3360 15270 -3240 {lab=GNDA}
N 15270 -3240 15620 -3240 {lab=GNDA}
N 15270 -2850 15360 -2850 {lab=GNDA}
N 15180 -2850 15230 -2850 {lab=GNDA}
N 15270 -2790 15540 -2790 {lab=GNDA}
N 15270 -2820 15270 -2790 {lab=GNDA}
N 15180 -2850 15180 -2790 {lab=GNDA}
N 15180 -2790 15270 -2790 {lab=GNDA}
N 15360 -2850 15360 -2790 {lab=GNDA}
N 15270 -3000 15270 -2880 {lab=VDDA}
N 15270 -3000 15620 -3000 {lab=VDDA}
N 14300 -2850 14390 -2850 {lab=GNDA}
N 14430 -2850 14480 -2850 {lab=GNDA}
N 14140 -2790 14390 -2790 {lab=GNDA}
N 14390 -2820 14390 -2790 {lab=GNDA}
N 14480 -2850 14480 -2790 {lab=GNDA}
N 14390 -2790 14480 -2790 {lab=GNDA}
N 14300 -2850 14300 -2790 {lab=GNDA}
N 14390 -3000 14390 -2880 {lab=VDDA}
N 14060 -3000 14390 -3000 {lab=VDDA}
N 19420 -2120 19490 -2120 {lab=GNDA}
N 19420 -2190 19420 -2120 {lab=GNDA}
N 19420 -2190 19490 -2190 {lab=GNDA}
N 19490 -2160 19490 -2050 {lab=GNDA}
N 19200 -2050 19490 -2050 {lab=GNDA}
N 17820 -2890 17890 -2890 {lab=VDDA}
N 17890 -2960 17890 -2890 {lab=VDDA}
N 17820 -2960 17890 -2960 {lab=VDDA}
N 17820 -2960 17820 -2920 {lab=VDDA}
N 17720 -2890 17780 -2890 {lab=VDDA}
N 17720 -2960 17720 -2890 {lab=VDDA}
N 17720 -2960 17820 -2960 {lab=VDDA}
N 17820 -3000 17820 -2960 {lab=VDDA}
N 17820 -3000 18130 -3000 {lab=VDDA}
N 19530 -2190 19590 -2190 {lab=GNDA}
N 19590 -2190 19590 -2120 {lab=GNDA}
N 19490 -2120 19590 -2120 {lab=GNDA}
N 19490 -2260 19490 -2220 {lab=VOUT+}
N 19200 -2260 19490 -2260 {lab=VOUT+}
N 17840 -2120 17910 -2120 {lab=GNDA}
N 17910 -2190 17910 -2120 {lab=GNDA}
N 17840 -2190 17910 -2190 {lab=GNDA}
N 17840 -2160 17840 -2050 {lab=GNDA}
N 17840 -2050 18130 -2050 {lab=GNDA}
N 17740 -2190 17800 -2190 {lab=GNDA}
N 17740 -2190 17740 -2120 {lab=GNDA}
N 17740 -2120 17840 -2120 {lab=GNDA}
N 17840 -2260 17840 -2220 {lab=VOUT-}
N 17840 -2260 18130 -2260 {lab=VOUT-}
N 19440 -2890 19510 -2890 {lab=VDDA}
N 19440 -2960 19440 -2890 {lab=VDDA}
N 19440 -2960 19510 -2960 {lab=VDDA}
N 19510 -2960 19510 -2920 {lab=VDDA}
N 19510 -2860 19510 -2790 {lab=VOUT+}
N 19200 -2790 19510 -2790 {lab=VOUT+}
N 19550 -2890 19610 -2890 {lab=VDDA}
N 19610 -2960 19610 -2890 {lab=VDDA}
N 19510 -2960 19610 -2960 {lab=VDDA}
N 19510 -3000 19510 -2960 {lab=VDDA}
N 19200 -3000 19510 -3000 {lab=VDDA}
N 7500 -1300 7620 -1300 {lab=GNDA}
N 7620 -1300 7620 -1210 {lab=GNDA}
N 7500 -1210 7620 -1210 {lab=GNDA}
N 9210 -1300 9330 -1300 {lab=GNDA}
N 9210 -1300 9210 -1210 {lab=GNDA}
N 9210 -1210 9330 -1210 {lab=GNDA}
N 17820 -2860 17820 -2790 {lab=VOUT-}
N 17820 -2790 18130 -2790 {lab=VOUT-}
N 12990 -1310 13030 -1310 {lab=GNDA}
N 12990 -1310 12990 -1260 {lab=GNDA}
N 12990 -1260 13030 -1260 {lab=GNDA}
N 13030 -1280 13030 -1200 {lab=GNDA}
N 12800 -1200 13030 -1200 {lab=GNDA}
N 13070 -1310 13110 -1310 {lab=GNDA}
N 13110 -1310 13110 -1260 {lab=GNDA}
N 13030 -1260 13110 -1260 {lab=GNDA}
N 13030 -1390 13030 -1340 {lab=err_amp_mir}
N 12800 -1390 13030 -1390 {lab=err_amp_mir}
N 12330 -1310 12370 -1310 {lab=GNDA}
N 12370 -1310 12370 -1260 {lab=GNDA}
N 12330 -1260 12370 -1260 {lab=GNDA}
N 12330 -1280 12330 -1200 {lab=GNDA}
N 12330 -1200 12560 -1200 {lab=GNDA}
N 12250 -1310 12290 -1310 {lab=GNDA}
N 12250 -1310 12250 -1260 {lab=GNDA}
N 12250 -1260 12330 -1260 {lab=GNDA}
N 12330 -1390 12330 -1340 {lab=err_amp_out}
N 12330 -1390 12560 -1390 {lab=err_amp_out}
N 7590 -2410 7660 -2410 {lab=GNDA}
N 7590 -2410 7590 -2320 {lab=GNDA}
N 7590 -2320 7700 -2320 {lab=GNDA}
N 7700 -2380 7700 -2230 {lab=GNDA}
N 7700 -2530 7700 -2440 {lab=X}
N 7700 -2530 8040 -2530 {lab=X}
N 7700 -2410 7805 -2410 {lab=GNDA}
N 7805 -2410 7805 -2320 {lab=GNDA}
N 7700 -2320 7805 -2320 {lab=GNDA}
N 9850 -5580 9850 -5380 {lab=GNDA}
N 9850 -6430 9850 -6270 {
lab=VDDA}
N 9850 -6240 9890 -6240 {lab=VDDA}
N 9890 -6310 9890 -6240 {lab=VDDA}
N 9850 -6310 9890 -6310 {lab=VDDA}
N 9850 -6120 9950 -6120 {lab=V_err_amp_ref}
N 9850 -6210 9850 -5640 {lab=V_err_amp_ref}
N 10600 -6100 10640 -6100 {lab=VDDA}
N 10640 -6170 10640 -6100 {lab=VDDA}
N 10600 -6170 10640 -6170 {lab=VDDA}
N 10410 -6100 10560 -6100 {lab=PFET_GATE_10uA}
N 10230 -6080 10280 -6080 {lab=V_CUR_REF_REG}
N 10230 -6080 10230 -5820 {lab=V_CUR_REF_REG}
N 10230 -5820 10600 -5820 {lab=V_CUR_REF_REG}
N 10600 -6070 10600 -5640 {lab=V_CUR_REF_REG}
N 9950 -6120 10280 -6120 {lab=V_err_amp_ref}
N 9850 -6430 10600 -6430 {lab=VDDA}
N 10600 -6430 10600 -6130 {lab=VDDA}
N 9850 -5380 10600 -5380 {lab=GNDA}
N 10600 -5580 10600 -5380 {lab=GNDA}
N 10500 -6100 10500 -6000 {lab=PFET_GATE_10uA}
N 10500 -6000 10990 -6000 {lab=PFET_GATE_10uA}
N 9580 -6310 9580 -6240 {lab=V_TOP}
N 9580 -6430 9580 -6370 {lab=VDDA}
N 9440 -6430 9850 -6430 {lab=VDDA}
N 8650 -5380 9030 -5380 {
lab=GNDA}
N 8610 -5460 8610 -5380 {
lab=GNDA}
N 8990 -5460 8990 -5380 {
lab=GNDA}
N 8610 -5380 8650 -5380 {
lab=GNDA}
N 8690 -6320 8830 -6320 {
lab=V_TOP}
N 8830 -6320 8990 -6320 {
lab=V_TOP}
N 8650 -6430 8650 -6350 {
lab=VDDA}
N 8650 -6430 9030 -6430 {
lab=VDDA}
N 9030 -6430 9030 -6350 {
lab=VDDA}
N 9030 -5580 9030 -5490 {lab=Vbe2}
N 9290 -5580 9290 -5380 {lab=GNDA}
N 8410 -5580 8410 -5380 {lab=GNDA}
N 9030 -6320 9070 -6320 {lab=VDDA}
N 9070 -6390 9070 -6320 {lab=VDDA}
N 9030 -6390 9070 -6390 {lab=VDDA}
N 8610 -6320 8650 -6320 {lab=VDDA}
N 8610 -6390 8610 -6320 {lab=VDDA}
N 8610 -6390 8650 -6390 {lab=VDDA}
N 8410 -5380 8610 -5380 {lab=GNDA}
N 9030 -5430 9030 -5380 {lab=GNDA}
N 8650 -5430 8650 -5380 {lab=GNDA}
N 7890 -6320 7890 -6240 {lab=V_TOP}
N 7640 -6180 7640 -6050 {lab=START_UP}
N 7640 -6430 7640 -6350 {
lab=VDDA}
N 7600 -6320 7640 -6320 {lab=VDDA}
N 7600 -6390 7600 -6320 {lab=VDDA}
N 7600 -6390 7640 -6390 {lab=VDDA}
N 7640 -6290 7640 -6180 {lab=START_UP}
N 7640 -6430 8650 -6430 {lab=VDDA}
N 7890 -6320 8450 -6320 {lab=V_TOP}
N 8450 -6320 8450 -6270 {lab=V_TOP}
N 8450 -6270 8770 -6270 {lab=V_TOP}
N 7640 -6210 7850 -6210 {lab=START_UP}
N 7640 -5380 8410 -5380 {lab=GNDA}
N 8770 -6320 8770 -6270 {lab=V_TOP}
N 7890 -6010 8650 -6010 {lab=bgr_Vin-}
N 7600 -6020 7600 -5950 {lab=GNDA}
N 7600 -6020 7640 -6020 {lab=GNDA}
N 7640 -5460 7640 -5380 {lab=GNDA}
N 7890 -6210 7930 -6210 {lab=VDDA}
N 7640 -5640 7640 -5460 {lab=GNDA}
N 7680 -6320 7890 -6320 {lab=V_TOP}
N 7640 -6080 7700 -6080 {lab=START_UP}
N 7700 -6080 7700 -6020 {lab=START_UP}
N 7680 -6020 7700 -6020 {lab=START_UP}
N 7890 -6180 7890 -6010 {lab=bgr_Vin-}
N 8410 -5790 8410 -5640 {lab=bgr_Vin-}
N 9290 -5790 9290 -5640 {lab=bgr_Vin+}
N 8840 -5380 8840 -5310 {lab=GNDA}
N 8350 -5610 8390 -5610 {lab=GNDA}
N 8970 -5610 9010 -5610 {lab=GNDA}
N 9310 -5610 9350 -5610 {lab=GNDA}
N 8750 -5980 8770 -5980 {lab=GNDA}
N 8890 -5980 8910 -5980 {lab=VDDA}
N 7930 -6430 7930 -6210 {lab=VDDA}
N 8850 -5920 8850 -5790 {lab=bgr_Vin+}
N 8810 -5920 8810 -5790 {lab=bgr_Vin-}
N 8850 -5790 9290 -5790 {lab=bgr_Vin+}
N 8410 -5790 8810 -5790 {lab=bgr_Vin-}
N 8830 -6320 8830 -6050 {lab=V_TOP}
N 9030 -5790 9030 -5640 {lab=bgr_Vin+}
N 9030 -6290 9030 -5790 {lab=bgr_Vin+}
N 8650 -5790 8650 -5490 {lab=bgr_Vin-}
N 8650 -6290 8650 -5790 {lab=bgr_Vin-}
N 7600 -5600 7640 -5600 {lab=GNDA}
N 7600 -5670 7600 -5600 {lab=GNDA}
N 7600 -5670 7640 -5670 {lab=GNDA}
N 7640 -5730 7700 -5730 {lab=START_UP_NFET1}
N 7700 -5730 7700 -5670 {lab=START_UP_NFET1}
N 7680 -5670 7700 -5670 {lab=START_UP_NFET1}
N 7640 -5990 7640 -5700 {lab=START_UP_NFET1}
N 9030 -5380 9290 -5380 {lab=GNDA}
N 9290 -5380 9850 -5380 {lab=GNDA}
N 9030 -6430 9440 -6430 {lab=VDDA}
N 8930 -6240 9810 -6240 {lab=V_TOP}
N 8930 -6320 8930 -6240 {lab=V_TOP}
N 9870 -5610 9910 -5610 {lab=GNDA}
N 10540 -5610 10580 -5610 {lab=GNDA}
N 10230 -6260 10230 -6120 {lab=V_err_amp_ref}
N 10230 -6260 14700 -6260 {lab=V_err_amp_ref}
N 8840 -6500 8840 -6430 {lab=VDDA}
N 11310 -6100 11350 -6100 {lab=VDDA}
N 11350 -6170 11350 -6100 {lab=VDDA}
N 11310 -6170 11350 -6170 {lab=VDDA}
N 11310 -5500 11310 -5380 {lab=GNDA}
N 11260 -5470 11310 -5470 {lab=GNDA}
N 11260 -5530 11260 -5470 {lab=GNDA}
N 11260 -5530 11310 -5530 {lab=GNDA}
N 11380 -5600 11380 -5530 {lab=NFET_GATE_10uA}
N 11310 -5600 11380 -5600 {lab=NFET_GATE_10uA}
N 11350 -5530 11840 -5530 {lab=NFET_GATE_10uA}
N 11310 -6070 11310 -5560 {lab=NFET_GATE_10uA}
N 10600 -5380 11310 -5380 {lab=GNDA}
N 10600 -6430 11310 -6430 {lab=VDDA}
N 11310 -6430 11310 -6130 {lab=VDDA}
N 10990 -6100 11270 -6100 {lab=PFET_GATE_10uA}
N 10990 -6100 10990 -6000 {lab=PFET_GATE_10uA}
N 12030 -5500 12030 -5380 {lab=GNDA}
N 12030 -5470 12080 -5470 {lab=GNDA}
N 12080 -5530 12080 -5470 {lab=GNDA}
N 12030 -5530 12080 -5530 {lab=GNDA}
N 12030 -5730 12030 -5560 {lab=Vb2}
N 11920 -5530 11990 -5530 {lab=NFET_GATE_10uA}
N 12630 -5500 12630 -5380 {lab=GNDA}
N 12630 -5470 12680 -5470 {lab=GNDA}
N 12680 -5530 12680 -5470 {lab=GNDA}
N 12630 -5530 12680 -5530 {lab=GNDA}
N 12630 -5730 12630 -5560 {lab=Vb3}
N 12520 -5530 12590 -5530 {lab=NFET_GATE_10uA}
N 11840 -5530 11920 -5530 {lab=NFET_GATE_10uA}
N 11310 -5380 12030 -5380 {lab=GNDA}
N 12030 -5380 12630 -5380 {lab=GNDA}
N 11880 -5610 11880 -5530 {lab=NFET_GATE_10uA}
N 12520 -5610 12520 -5530 {lab=NFET_GATE_10uA}
N 12030 -6100 12080 -6100 {lab=VDDA}
N 12080 -6160 12080 -6100 {lab=VDDA}
N 12030 -6160 12080 -6160 {lab=VDDA}
N 11860 -6100 11990 -6100 {lab=PFET_GATE_10uA}
N 12030 -6430 12030 -6130 {lab=VDDA}
N 11310 -6430 12030 -6430 {lab=VDDA}
N 11210 -6100 11210 -6000 {lab=PFET_GATE_10uA}
N 11210 -6000 11860 -6000 {lab=PFET_GATE_10uA}
N 11860 -6100 11860 -6000 {lab=PFET_GATE_10uA}
N 12030 -6070 12030 -5880 {lab=Vb1}
N 13250 -5470 13300 -5470 {lab=GNDA}
N 13300 -5530 13300 -5470 {lab=GNDA}
N 13250 -5530 13300 -5530 {lab=GNDA}
N 13140 -5530 13210 -5530 {lab=NFET_GATE_10uA}
N 13140 -5610 13140 -5530 {lab=NFET_GATE_10uA}
N 13250 -5730 13250 -5560 {lab=V_err_gate}
N 13250 -5500 13250 -5380 {lab=GNDA}
N 13670 -5470 13720 -5470 {lab=GNDA}
N 13720 -5530 13720 -5470 {lab=GNDA}
N 13670 -5530 13720 -5530 {lab=GNDA}
N 13560 -5530 13630 -5530 {lab=NFET_GATE_10uA}
N 13560 -5610 13560 -5530 {lab=NFET_GATE_10uA}
N 13670 -5730 13670 -5560 {lab=V_CMFB_S2}
N 13670 -5500 13670 -5380 {lab=GNDA}
N 12770 -6100 12820 -6100 {lab=VDDA}
N 12820 -6160 12820 -6100 {lab=VDDA}
N 12770 -6160 12820 -6160 {lab=VDDA}
N 12600 -6100 12730 -6100 {lab=PFET_GATE_10uA}
N 12770 -6430 12770 -6130 {lab=VDDA}
N 12600 -6100 12600 -6000 {lab=PFET_GATE_10uA}
N 12770 -6070 12770 -5880 {lab=V_tail_gate}
N 11860 -6000 12460 -6000 {lab=PFET_GATE_10uA}
N 12030 -6430 12630 -6430 {lab=VDDA}
N 11880 -5610 12520 -5610 {lab=NFET_GATE_10uA}
N 11470 -6100 11510 -6100 {lab=VDDA}
N 11470 -6170 11470 -6100 {lab=VDDA}
N 11470 -6170 11510 -6170 {lab=VDDA}
N 11510 -6430 11510 -6130 {lab=VDDA}
N 11510 -6170 11590 -6170 {lab=VDDA}
N 11590 -6170 11590 -6100 {lab=VDDA}
N 11550 -6100 11590 -6100 {lab=VDDA}
N 11510 -6070 11510 -6040 {lab=NFET_GATE_10uA}
N 11310 -6040 11510 -6040 {lab=NFET_GATE_10uA}
N 11130 -5500 11130 -5380 {lab=GNDA}
N 11130 -5470 11180 -5470 {lab=GNDA}
N 11180 -5530 11180 -5470 {lab=GNDA}
N 11130 -5530 11180 -5530 {lab=GNDA}
N 11050 -5530 11090 -5530 {lab=GNDA}
N 11050 -5470 11130 -5470 {lab=GNDA}
N 11050 -5530 11050 -5470 {lab=GNDA}
N 11130 -5600 11310 -5600 {lab=NFET_GATE_10uA}
N 11130 -5600 11130 -5560 {lab=NFET_GATE_10uA}
N 10760 -6100 10800 -6100 {lab=VDDA}
N 10760 -6170 10760 -6100 {lab=VDDA}
N 10760 -6170 10800 -6170 {lab=VDDA}
N 10800 -6430 10800 -6130 {lab=VDDA}
N 10800 -6170 10880 -6170 {lab=VDDA}
N 10880 -6170 10880 -6100 {lab=VDDA}
N 10840 -6100 10880 -6100 {lab=VDDA}
N 10800 -6070 10800 -6040 {lab=V_CUR_REF_REG}
N 10600 -6040 10800 -6040 {lab=V_CUR_REF_REG}
N 12810 -5500 12810 -5380 {lab=GNDA}
N 12760 -5470 12810 -5470 {lab=GNDA}
N 12760 -5530 12760 -5470 {lab=GNDA}
N 12760 -5530 12810 -5530 {lab=GNDA}
N 12850 -5530 12890 -5530 {lab=GNDA}
N 12810 -5470 12890 -5470 {lab=GNDA}
N 12890 -5530 12890 -5470 {lab=GNDA}
N 12630 -5650 12810 -5650 {lab=Vb3}
N 12810 -5650 12810 -5560 {lab=Vb3}
N 12630 -5380 12810 -5380 {lab=GNDA}
N 13250 -5380 13670 -5380 {lab=GNDA}
N 13670 -6100 13720 -6100 {lab=VDDA}
N 13720 -6160 13720 -6100 {lab=VDDA}
N 13670 -6160 13720 -6160 {lab=VDDA}
N 13500 -6100 13630 -6100 {lab=PFET_GATE_10uA}
N 13670 -6430 13670 -6130 {lab=VDDA}
N 13500 -6100 13500 -6000 {lab=PFET_GATE_10uA}
N 13670 -6070 13670 -5880 {lab=V_CMFB_S1}
N 12460 -6000 13500 -6000 {lab=PFET_GATE_10uA}
N 12630 -6430 13670 -6430 {lab=VDDA}
N 7600 -5950 7600 -5670 {lab=GNDA}
N 10080 -6430 10080 -6270 {
lab=VDDA}
N 10080 -6240 10120 -6240 {lab=VDDA}
N 10120 -6310 10120 -6240 {lab=VDDA}
N 10080 -6310 10120 -6310 {lab=VDDA}
N 9990 -6240 10040 -6240 {lab=VDDA}
N 9990 -6310 9990 -6240 {lab=VDDA}
N 9990 -6310 10080 -6310 {lab=VDDA}
N 9850 -6170 10080 -6170 {lab=V_err_amp_ref}
N 14240 -5470 14290 -5470 {lab=GNDA}
N 14290 -5530 14290 -5470 {lab=GNDA}
N 14240 -5530 14290 -5530 {lab=GNDA}
N 14240 -5500 14240 -5380 {lab=GNDA}
N 13670 -5380 14240 -5380 {lab=GNDA}
N 14240 -5730 14240 -5560 {lab=V_CMFB_S4}
N 14120 -5610 14120 -5530 {lab=NFET_GATE_10uA}
N 14120 -5530 14200 -5530 {lab=NFET_GATE_10uA}
N 14240 -6100 14290 -6100 {lab=VDDA}
N 14290 -6160 14290 -6100 {lab=VDDA}
N 14240 -6160 14290 -6160 {lab=VDDA}
N 14070 -6100 14200 -6100 {lab=PFET_GATE_10uA}
N 14240 -6430 14240 -6130 {lab=VDDA}
N 14070 -6100 14070 -6000 {lab=PFET_GATE_10uA}
N 14240 -6070 14240 -5880 {lab=V_CMFB_S3}
N 12520 -5610 13140 -5610 {lab=NFET_GATE_10uA}
N 13140 -5610 13560 -5610 {lab=NFET_GATE_10uA}
N 13560 -5610 14120 -5610 {lab=NFET_GATE_10uA}
N 13850 -5500 13850 -5380 {lab=GNDA}
N 13800 -5470 13850 -5470 {lab=GNDA}
N 13800 -5530 13800 -5470 {lab=GNDA}
N 13800 -5530 13850 -5530 {lab=GNDA}
N 13890 -5530 13930 -5530 {lab=GNDA}
N 13850 -5470 13930 -5470 {lab=GNDA}
N 13930 -5530 13930 -5470 {lab=GNDA}
N 13670 -5650 13850 -5650 {lab=V_CMFB_S2}
N 13850 -5650 13850 -5560 {lab=V_CMFB_S2}
N 14420 -5500 14420 -5380 {lab=GNDA}
N 14370 -5470 14420 -5470 {lab=GNDA}
N 14370 -5530 14370 -5470 {lab=GNDA}
N 14370 -5530 14420 -5530 {lab=GNDA}
N 14460 -5530 14500 -5530 {lab=GNDA}
N 14420 -5470 14500 -5470 {lab=GNDA}
N 14500 -5530 14500 -5470 {lab=GNDA}
N 14240 -5650 14420 -5650 {lab=V_CMFB_S4}
N 14420 -5650 14420 -5560 {lab=V_CMFB_S4}
N 14240 -5380 14420 -5380 {lab=GNDA}
N 12210 -5500 12210 -5380 {lab=GNDA}
N 12160 -5470 12210 -5470 {lab=GNDA}
N 12160 -5530 12160 -5470 {lab=GNDA}
N 12160 -5530 12210 -5530 {lab=GNDA}
N 12250 -5530 12290 -5530 {lab=GNDA}
N 12210 -5470 12290 -5470 {lab=GNDA}
N 12290 -5530 12290 -5470 {lab=GNDA}
N 12030 -5650 12210 -5650 {lab=Vb2}
N 12210 -5650 12210 -5560 {lab=Vb2}
N 13830 -6100 13870 -6100 {lab=VDDA}
N 13830 -6170 13830 -6100 {lab=VDDA}
N 13830 -6170 13870 -6170 {lab=VDDA}
N 13870 -6430 13870 -6130 {lab=VDDA}
N 13870 -6170 13950 -6170 {lab=VDDA}
N 13950 -6170 13950 -6100 {lab=VDDA}
N 13910 -6100 13950 -6100 {lab=VDDA}
N 13870 -6070 13870 -6040 {lab=V_CMFB_S1}
N 13670 -6040 13870 -6040 {lab=V_CMFB_S1}
N 14400 -6100 14440 -6100 {lab=VDDA}
N 14400 -6170 14400 -6100 {lab=VDDA}
N 14400 -6170 14440 -6170 {lab=VDDA}
N 14440 -6430 14440 -6130 {lab=VDDA}
N 14440 -6170 14520 -6170 {lab=VDDA}
N 14520 -6170 14520 -6100 {lab=VDDA}
N 14480 -6100 14520 -6100 {lab=VDDA}
N 14440 -6070 14440 -6040 {lab=V_CMFB_S3}
N 14240 -6040 14440 -6040 {lab=V_CMFB_S3}
N 14240 -6430 14440 -6430 {lab=VDDA}
N 12190 -6100 12230 -6100 {lab=VDDA}
N 12190 -6170 12190 -6100 {lab=VDDA}
N 12190 -6170 12230 -6170 {lab=VDDA}
N 12230 -6430 12230 -6130 {lab=VDDA}
N 12230 -6170 12310 -6170 {lab=VDDA}
N 12310 -6170 12310 -6100 {lab=VDDA}
N 12270 -6100 12310 -6100 {lab=VDDA}
N 12230 -6070 12230 -6040 {lab=Vb1}
N 12030 -6040 12230 -6040 {lab=Vb1}
N 12810 -5380 13250 -5380 {lab=GNDA}
N 10080 -6210 10080 -6170 {lab=V_err_amp_ref}
N 8100 -6180 8100 -6110 {lab=V_TOP}
N 7930 -6210 8100 -6210 {lab=VDDA}
N 8100 -6430 8100 -6240 {lab=VDDA}
N 8140 -6210 8180 -6210 {lab=VDDA}
N 8180 -6290 8180 -6210 {lab=VDDA}
N 8100 -6290 8180 -6290 {lab=VDDA}
N 7890 -6270 7990 -6270 {lab=V_TOP}
N 7990 -6270 7990 -6110 {lab=V_TOP}
N 7990 -6110 8100 -6110 {lab=V_TOP}
N 9000 -3190 9130 -3190 {lab=VDDA}
N 9000 -3280 9000 -3190 {lab=VDDA}
N 9000 -3280 9130 -3280 {lab=VDDA}
N 9130 -3280 9130 -3220 {lab=VDDA}
N 9260 -3280 9260 -3190 {lab=VDDA}
N 9130 -3280 9260 -3280 {lab=VDDA}
N 9170 -3190 9260 -3190 {lab=VDDA}
N 8790 -3340 9130 -3340 {lab=VDDA}
N 9130 -3340 9130 -3280 {lab=VDDA}
N 9130 -3160 9130 -3100 {lab=VD4}
N 8790 -3100 9130 -3100 {lab=VD4}
N 13670 -6430 14240 -6430 {lab=VDDA}
N 13500 -6000 14070 -6000 {lab=PFET_GATE_10uA}
N 3430 -2670 3430 -1510 {lab=Vb2_Vb3}
N 3360 -1480 3430 -1480 {lab=Vb2_Vb3}
N 3360 -1550 3360 -1480 {lab=Vb2_Vb3}
N 3360 -1550 3430 -1550 {lab=Vb2_Vb3}
N 3430 -3580 3430 -2730 {lab=VDDA}
N 3360 -2700 3430 -2700 {lab=VDDA}
N 3360 -2770 3360 -2700 {lab=VDDA}
N 3360 -2770 3430 -2770 {lab=VDDA}
N 2460 -3670 2460 -3580 {lab=VDDA}
N 1380 -3580 3430 -3580 {lab=VDDA}
N 3470 -2700 3550 -2700 {lab=Vb3}
N 3550 -2700 3550 -1380 {lab=Vb3}
N 3430 -1380 3550 -1380 {lab=Vb3}
N 3470 -1480 3630 -1480 {lab=Vb2}
N 3800 -2700 3870 -2700 {lab=VDDA}
N 3800 -2770 3800 -2700 {lab=VDDA}
N 3800 -2770 3870 -2770 {lab=VDDA}
N 3870 -2810 3870 -2730 {lab=VDDA}
N 3430 -2810 3870 -2810 {lab=VDDA}
N 3910 -2700 3950 -2700 {lab=VDDA}
N 3950 -2750 3950 -2700 {lab=VDDA}
N 3870 -2750 3950 -2750 {lab=VDDA}
N 3430 -2570 3870 -2570 {lab=Vb2_Vb3}
N 3870 -2670 3870 -2570 {lab=Vb2_Vb3}
N 3800 -1480 3870 -1480 {lab=Vb2_Vb3}
N 3800 -1550 3800 -1480 {lab=Vb2_Vb3}
N 3800 -1550 3870 -1550 {lab=Vb2_Vb3}
N 3870 -1600 3870 -1510 {lab=Vb2_Vb3}
N 3910 -1480 3950 -1480 {lab=Vb2_Vb3}
N 3950 -1530 3950 -1480 {lab=Vb2_Vb3}
N 3870 -1530 3950 -1530 {lab=Vb2_Vb3}
N 3430 -1600 3870 -1600 {lab=Vb2_Vb3}
N 3870 -1450 3870 -1330 {lab=Vb3}
N 3430 -1330 3870 -1330 {lab=Vb3}
N 3430 -1450 3430 -890 {lab=Vb3}
N 1380 -2670 1380 -1510 {lab=Vb2_2}
N 1310 -1480 1380 -1480 {lab=Vb2_2}
N 1310 -1550 1310 -1480 {lab=Vb2_2}
N 1310 -1550 1380 -1550 {lab=Vb2_2}
N 1310 -2700 1380 -2700 {lab=VDDA}
N 1310 -2770 1310 -2700 {lab=VDDA}
N 1310 -2770 1380 -2770 {lab=VDDA}
N 1420 -2700 1500 -2700 {lab=Vb2}
N 1500 -2700 1500 -1380 {lab=Vb2}
N 1380 -1380 1500 -1380 {lab=Vb2}
N 1750 -2700 1820 -2700 {lab=VDDA}
N 1750 -2770 1750 -2700 {lab=VDDA}
N 1750 -2770 1820 -2770 {lab=VDDA}
N 1820 -2810 1820 -2730 {lab=VDDA}
N 1380 -2810 1820 -2810 {lab=VDDA}
N 1860 -2700 1900 -2700 {lab=VDDA}
N 1900 -2750 1900 -2700 {lab=VDDA}
N 1820 -2750 1900 -2750 {lab=VDDA}
N 1380 -2570 1820 -2570 {lab=Vb2_2}
N 1820 -2670 1820 -2570 {lab=Vb2_2}
N 1750 -1480 1820 -1480 {lab=Vb2_2}
N 1750 -1550 1750 -1480 {lab=Vb2_2}
N 1750 -1550 1820 -1550 {lab=Vb2_2}
N 1820 -1600 1820 -1510 {lab=Vb2_2}
N 1860 -1480 1900 -1480 {lab=Vb2_2}
N 1900 -1530 1900 -1480 {lab=Vb2_2}
N 1820 -1530 1900 -1530 {lab=Vb2_2}
N 1380 -1600 1820 -1600 {lab=Vb2_2}
N 1820 -1450 1820 -1330 {lab=Vb2}
N 1380 -1330 1820 -1330 {lab=Vb2}
N 1420 -1480 1500 -1480 {lab=Vb2}
N 1380 -3580 1380 -2730 {lab=VDDA}
N 1380 -1450 1380 -890 {lab=Vb2}
N 1500 -1480 1580 -1480 {lab=Vb2}
N 2990 -3280 3060 -3280 {lab=VDDA}
N 3060 -3350 3060 -3280 {lab=VDDA}
N 2990 -3350 3060 -3350 {lab=VDDA}
N 2990 -3390 2990 -3310 {lab=VDDA}
N 2910 -3280 2950 -3280 {lab=VDDA}
N 2910 -3330 2910 -3280 {lab=VDDA}
N 2910 -3330 2990 -3330 {lab=VDDA}
N 2990 -3250 2990 -3150 {lab=VDDA}
N 2990 -2060 3060 -2060 {lab=Vb2_Vb3}
N 3060 -2130 3060 -2060 {lab=Vb2_Vb3}
N 2990 -2130 3060 -2130 {lab=Vb2_Vb3}
N 2990 -2180 2990 -2090 {lab=Vb2_Vb3}
N 2910 -2060 2950 -2060 {lab=Vb2_Vb3}
N 2910 -2110 2910 -2060 {lab=Vb2_Vb3}
N 2910 -2110 2990 -2110 {lab=Vb2_Vb3}
N 2990 -2030 2990 -1910 {lab=Vb2_Vb3}
N 2990 -3390 3430 -3390 {lab=VDDA}
N 2990 -3150 3430 -3150 {lab=VDDA}
N 2990 -2180 3430 -2180 {lab=Vb2_Vb3}
N 2990 -1910 3430 -1910 {lab=Vb2_Vb3}
N 940 -3280 1010 -3280 {lab=VDDA}
N 1010 -3350 1010 -3280 {lab=VDDA}
N 940 -3350 1010 -3350 {lab=VDDA}
N 940 -3390 940 -3310 {lab=VDDA}
N 860 -3280 900 -3280 {lab=VDDA}
N 860 -3330 860 -3280 {lab=VDDA}
N 860 -3330 940 -3330 {lab=VDDA}
N 940 -3250 940 -3150 {lab=VDDA}
N 940 -2060 1010 -2060 {lab=Vb2_2}
N 1010 -2130 1010 -2060 {lab=Vb2_2}
N 940 -2130 1010 -2130 {lab=Vb2_2}
N 940 -2180 940 -2090 {lab=Vb2_2}
N 860 -2060 900 -2060 {lab=Vb2_2}
N 860 -2110 860 -2060 {lab=Vb2_2}
N 860 -2110 940 -2110 {lab=Vb2_2}
N 940 -2030 940 -1910 {lab=Vb2_2}
N 940 -3390 1380 -3390 {lab=VDDA}
N 940 -3150 1380 -3150 {lab=VDDA}
N 940 -2180 1380 -2180 {lab=Vb2_2}
N 940 -1910 1380 -1910 {lab=Vb2_2}
N 8340 -2000 8490 -2000 {lab=GNDA}
N 8210 -2000 8300 -2000 {lab=Vb1}
N 8210 -2120 8210 -2000 {lab=Vb1}
N 8340 -2120 8340 -2030 {lab=Vb1_2}
N 8340 -2140 8340 -2120 {lab=Vb1_2}
N 8210 -2170 8300 -2170 {lab=Vb1}
N 8210 -2170 8210 -2120 {lab=Vb1}
N 8340 -2170 8490 -2170 {lab=GNDA}
N 8210 -2310 8210 -2170 {lab=Vb1}
N 8210 -2310 8340 -2310 {lab=Vb1}
N 8340 -2310 8340 -2200 {lab=Vb1}
N 8340 -2410 8340 -2310 {lab=Vb1}
N 8490 -2350 8490 -1800 {lab=GNDA}
N 8650 -2170 8720 -2170 {lab=GNDA}
N 8720 -2170 8720 -2080 {lab=GNDA}
N 8610 -2080 8720 -2080 {lab=GNDA}
N 8610 -2140 8610 -1990 {lab=GNDA}
N 8340 -2310 8610 -2310 {lab=Vb1}
N 8610 -2310 8610 -2200 {lab=Vb1}
N 8490 -2170 8610 -2170 {lab=GNDA}
N 12930 -6100 12970 -6100 {lab=VDDA}
N 12930 -6170 12930 -6100 {lab=VDDA}
N 12930 -6170 12970 -6170 {lab=VDDA}
N 12970 -6430 12970 -6130 {lab=VDDA}
N 12970 -6170 13050 -6170 {lab=VDDA}
N 13050 -6170 13050 -6100 {lab=VDDA}
N 13010 -6100 13050 -6100 {lab=VDDA}
N 12970 -6070 12970 -6040 {lab=VDDA}
N 12870 -6040 12970 -6040 {lab=VDDA}
N 12870 -6210 12870 -6040 {lab=VDDA}
N 12770 -6210 12870 -6210 {lab=VDDA}
N 8340 -1110 8960 -1110 {lab=GNDA}
N 8140 -1270 8140 -1110 {lab=GNDA}
N 8140 -1300 8240 -1300 {lab=GNDA}
N 8240 -1300 8240 -1110 {lab=GNDA}
N 8020 -1300 8100 -1300 {lab=GNDA}
N 8020 -1300 8020 -1110 {lab=GNDA}
N 8140 -1460 8340 -1460 {lab=GNDA}
N 8140 -1460 8140 -1330 {lab=GNDA}
N 6400 -1460 6400 -1430 {lab=GNDA}
C {sky130_fd_pr/nfet_01v8.sym} 8020 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8810 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8060 -2410 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8770 -2410 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8060 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8770 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8060 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8770 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8210 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 8210 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 8320 -1540 0 0 {name=M15
W=2.5
L=0.15
nf=1
mult=18
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6250 -1540 0 1 {name=M16
W=2.5
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6050 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6420 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8040 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {lab_pin.sym} 8790 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 14040 -2950 0 0 {name=M25
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14040 -3290 0 0 {name=M26
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 13820 -3130 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 15870 -3130 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14700 -3340 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14700 -2900 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14960 -3340 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14960 -2900 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_wire.sym} 14830 -3130 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 15640 -2950 0 1 {name=M27
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 15640 -3290 0 1 {name=M28
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12820 -2230 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12540 -2230 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12780 -1310 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12580 -1310 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 12920 -2230 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 12660 -2620 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11240 -2400 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11520 -2400 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 11630 -2400 0 1 {name=p34 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 11130 -2400 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 11400 -2620 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 18150 -2190 0 1 {name=M37
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 19180 -2190 0 0 {name=M38
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 18150 -2890 0 1 {name=M39
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19180 -2890 0 0 {name=M40
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 18500 -2890 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 18830 -2890 0 0 {name=p46 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 18290 -2310 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 19040 -2310 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 8660 -1540 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8340 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 8040 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 8790 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 7770 -1540 0 0 {name=p21 sig_type=std_logic lab=V_tail_gate}
C {lab_wire.sym} 6230 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 8040 -3000 0 1 {name=p23 sig_type=std_logic lab=VD3}
C {lab_pin.sym} 8790 -3000 0 0 {name=p57 sig_type=std_logic lab=VD4}
C {lab_pin.sym} 12800 -1560 0 1 {name=p33 sig_type=std_logic lab=err_amp_mir}
C {lab_wire.sym} 12640 -2330 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 11420 -2500 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 12020 -2620 0 1 {name=p39 sig_type=std_logic lab=V_err_gate}
C {lab_wire.sym} 12350 -1540 0 0 {name=p40 sig_type=std_logic lab=err_amp_out}
C {lab_wire.sym} 18670 -2190 2 0 {name=p43 sig_type=std_logic lab=V_b_2nd_stage}
C {lab_wire.sym} 8210 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6430 -2070 0 1 {name=p75 sig_type=std_logic lab=V_tail_gate}
C {ipin.sym} 7870 -1670 0 0 {name=p4 lab=VIN-}
C {ipin.sym} 8920 -1670 0 1 {name=p5 lab=VIN+}
C {lab_wire.sym} 18130 -3040 0 1 {name=p18 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 19200 -3040 0 1 {name=p19 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 11380 -2900 0 1 {name=p29 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 12680 -2900 0 1 {name=p30 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 14060 -3500 0 1 {name=p31 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 15620 -3500 0 1 {name=p49 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 14060 -3030 0 1 {name=p50 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 15620 -3030 0 1 {name=p51 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 18130 -1990 2 0 {name=p54 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 19200 -1990 2 0 {name=p55 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 6230 -1300 2 0 {name=p63 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 12680 -1150 2 0 {name=p65 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14700 -2880 2 0 {name=p66 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14060 -2760 2 0 {name=p68 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 15620 -2760 2 0 {name=p69 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14060 -3210 2 0 {name=p76 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 15620 -3210 2 0 {name=p77 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14700 -3360 0 1 {name=p78 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14960 -3360 0 0 {name=p79 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 18290 -2290 2 0 {name=p80 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 19040 -2290 2 0 {name=p81 sig_type=std_logic lab=GNDA}
C {opin.sym} 19450 -2500 0 0 {name=p59 lab=VOUT+}
C {opin.sym} 17890 -2500 0 1 {name=p47 lab=VOUT-}
C {lab_wire.sym} 14960 -2880 2 1 {name=p48 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/cap_mim_m3_1.sym} 19030 -2660 1 1 {name=C6 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 18300 -2660 3 0 {name=C7 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 6420 -1400 0 1 {name=M21
W=2.5
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5590 -1800 0 0 {name=M23
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7480 -1300 0 0 {name=M24
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9350 -1300 0 1 {name=M46
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9150 -2410 0 1 {name=M47
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7680 -3190 0 0 {name=M48
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -2770 0 1 {name=M49
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7680 -2770 0 0 {name=M52
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12250 -1900 0 0 {name=M59
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 12270 -2030 0 0 {name=p83 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 10870 -2400 0 0 {name=M60
W=2.5
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10890 -2530 0 0 {name=p86 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 13110 -1900 0 1 {name=M61
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 13090 -2030 0 1 {name=p87 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 15250 -3390 0 0 {name=M63
W=2
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 15250 -2850 0 0 {name=M64
W=3
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14410 -2850 0 1 {name=M65
W=3
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 19510 -2190 0 1 {name=M66
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 17800 -2890 0 0 {name=M68
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 17820 -2190 0 0 {name=M69
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19530 -2890 0 1 {name=M67
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 18450 -2660 0 1 {name=p11 sig_type=std_logic lab=cap_res_X}
C {lab_pin.sym} 18880 -2660 0 0 {name=p28 sig_type=std_logic lab=cap_res_Y}
C {sky130_fd_pr/res_high_po_1p41.sym} 18450 -2780 0 1 {name=R1
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_1p41.sym} 18880 -2780 0 0 {name=R2
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 13050 -1310 0 1 {name=M20
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12310 -1310 0 0 {name=M42
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 18470 -2780 1 1 {name=p52 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 18860 -2780 3 0 {name=p53 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/nfet_01v8.sym} 7680 -2410 0 0 {name=M44
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 9130 -2230 2 0 {name=p14 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 7700 -2230 2 1 {name=p44 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 11380 -2070 2 1 {name=p111 sig_type=std_logic lab=V_err_gate}
C {lab_pin.sym} 12430 -2230 0 0 {name=p2 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 6230 -2340 0 0 {name=p100 sig_type=std_logic lab=V_tail_gate}
C {lab_pin.sym} 8340 -2980 0 0 {name=p106 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 8220 -3400 0 1 {name=p105 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 8340 -1020 2 0 {name=p1 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 13940 -2900 2 1 {name=p3 sig_type=std_logic lab=V_CMFB_S2}
C {devices/lab_pin.sym} 15740 -2900 2 0 {name=p108 sig_type=std_logic lab=V_CMFB_S4}
C {devices/lab_pin.sym} 13940 -3340 2 1 {name=p114 sig_type=std_logic lab=V_CMFB_S1}
C {devices/lab_pin.sym} 15730 -3340 2 0 {name=p115 sig_type=std_logic lab=V_CMFB_S3}
C {sky130_fd_pr/pfet_01v8.sym} 9830 -6240 0 0 {name=M45
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9850 -5610 0 1 {name=R4
L=13.0
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10600 -5610 0 0 {name=R5
L=12
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 10580 -6100 0 0 {name=M50
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10600 -5820 0 1 {name=p41 sig_type=std_logic lab=V_CUR_REF_REG}
C {lab_wire.sym} 9680 -6240 2 0 {name=p56 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9580 -6340 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=20 spiceprefix=X}
C {lab_wire.sym} 10340 -6040 2 0 {name=p58 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 10340 -6160 0 1 {name=p62 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 9030 -5530 2 0 {name=p67 sig_type=std_logic lab=Vbe2}
C {sky130_fd_pr/pnp_05v5.sym} 8630 -5460 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 9010 -5460 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8670 -6320 0 1 {name=M51
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9010 -6320 0 0 {name=M53
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8930 -5790 2 0 {name=p70 sig_type=std_logic lab=bgr_Vin+}
C {lab_wire.sym} 8740 -5790 2 1 {name=p71 sig_type=std_logic lab=bgr_Vin-}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9030 -5610 0 0 {name=R3
L=2.3
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9290 -5610 0 1 {name=R6
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8410 -5610 0 0 {name=R7
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 7660 -6020 0 1 {name=M54
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7660 -6320 0 1 {name=M55
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7640 -6210 2 1 {name=p72 sig_type=std_logic lab=START_UP}
C {lab_wire.sym} 7890 -6320 0 0 {name=p73 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/pfet_01v8.sym} 7870 -6210 0 0 {name=M56
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {iopin.sym} 8840 -5310 0 0 {name=p74 lab=GNDA}
C {devices/lab_pin.sym} 8750 -5980 2 1 {name=p82 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 8350 -5610 2 1 {name=p84 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 8970 -5610 2 1 {name=p85 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 9350 -5610 2 0 {name=p88 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 8910 -5980 2 0 {name=p89 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/nfet_01v8.sym} 7660 -5670 0 1 {name=M57
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7640 -5910 2 0 {name=p90 sig_type=std_logic lab=START_UP_NFET1}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 8830 -5980 1 1 {name=x1}
C {devices/lab_pin.sym} 9910 -5610 2 0 {name=p91 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 10540 -5610 2 1 {name=p92 sig_type=std_logic lab=GNDA}
C {iopin.sym} 8840 -6500 2 1 {name=p94 lab=VDDA}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 10340 -6100 2 1 {name=x2}
C {sky130_fd_pr/pfet_01v8.sym} 11290 -6100 0 0 {name=M70
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11330 -5530 0 1 {name=M71
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12010 -5530 0 0 {name=M72
W=1
L=0.15
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12610 -5530 0 0 {name=M73
W=1
L=0.15
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12010 -6100 0 0 {name=M74
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13230 -5530 0 0 {name=M75
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13650 -5530 0 0 {name=M76
W=1
L=0.15
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12750 -6100 0 0 {name=M77
W=2
L=0.15
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10990 -6000 2 0 {name=p95 sig_type=std_logic lab=PFET_GATE_10uA}
C {lab_wire.sym} 11880 -5610 0 0 {name=p96 sig_type=std_logic lab=NFET_GATE_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 11530 -6100 0 1 {name=M78
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11110 -5530 0 0 {name=M79
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10820 -6100 0 1 {name=M80
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12830 -5530 0 1 {name=M81
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13650 -6100 0 0 {name=M82
W=1
L=0.15
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10060 -6240 0 0 {name=M83
W=6
L=0.5
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14220 -5530 0 0 {name=M84
W=1
L=0.15
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14220 -6100 0 0 {name=M85
W=1
L=0.15
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13870 -5530 0 1 {name=M86
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14440 -5530 0 1 {name=M87
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12230 -5530 0 1 {name=M88
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13890 -6100 0 1 {name=M89
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14460 -6100 0 1 {name=M90
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12250 -6100 0 1 {name=M91
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8120 -6210 0 1 {name=M92
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 12030 -5880 2 1 {name=p109 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 12030 -5730 2 1 {name=p64 sig_type=std_logic lab=Vb2}
C {devices/lab_pin.sym} 12630 -5730 2 1 {name=p97 sig_type=std_logic lab=Vb3}
C {devices/lab_pin.sym} 12770 -5880 2 1 {name=p98 sig_type=std_logic lab=V_tail_gate}
C {devices/lab_pin.sym} 13250 -5730 2 1 {name=p99 sig_type=std_logic lab=V_err_gate}
C {devices/lab_pin.sym} 13670 -5730 2 1 {name=p102 sig_type=std_logic lab=V_CMFB_S2}
C {devices/lab_pin.sym} 13670 -5880 2 1 {name=p101 sig_type=std_logic lab=V_CMFB_S1}
C {devices/lab_pin.sym} 14240 -5730 2 1 {name=p103 sig_type=std_logic lab=V_CMFB_S4}
C {devices/lab_pin.sym} 14240 -5880 2 1 {name=p104 sig_type=std_logic lab=V_CMFB_S3}
C {devices/lab_pin.sym} 14700 -6260 2 0 {name=p107 sig_type=std_logic lab=V_err_amp_ref}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -3190 0 1 {name=M93
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 14010 -3240 2 0 {name=r15 node=v(@m.x2.xm26.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 14010 -3000 0 1 {name=r8 node=v(@m.x2.xm25.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 15670 -3240 2 1 {name=r9 node=v(@m.x2.xm28.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 15670 -3000 0 0 {name=r14 node=v(@m.x2.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 3450 -1480 0 1 {name=M1
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3450 -2700 0 1 {name=M2
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3550 -2700 0 1 {name=p6 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 3630 -1480 0 1 {name=p7 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3430 -1620 0 0 {name=p8 sig_type=std_logic lab=Vb2_Vb3}
C {sky130_fd_pr/pfet_01v8.sym} 3890 -2700 0 1 {name=M3
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3890 -1480 0 1 {name=M4
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1400 -1480 0 1 {name=M94
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1400 -2700 0 1 {name=M95
W=1.8
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1580 -1480 0 1 {name=p12 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 1380 -1620 0 0 {name=p20 sig_type=std_logic lab=Vb2_2}
C {sky130_fd_pr/pfet_01v8.sym} 1840 -2700 0 1 {name=M96
W=1.8
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1840 -1480 0 1 {name=M97
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2460 -3670 0 1 {name=p93 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 2970 -3280 0 0 {name=M5
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2970 -2060 0 0 {name=M6
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 920 -3280 0 0 {name=M43
W=1.8
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 920 -2060 0 0 {name=M98
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1380 -890 0 1 {name=p110 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3430 -890 0 1 {name=p60 sig_type=std_logic lab=Vb3}
C {sky130_fd_pr/nfet_01v8.sym} 8320 -2000 0 0 {name=M19
W=1.5
L=3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8210 -2000 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/nfet_01v8.sym} 8320 -2170 0 0 {name=M58
W=1.5
L=0.15
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8340 -2080 0 1 {name=p61 sig_type=std_logic lab=Vb1_2}
C {devices/ngspice_get_value.sym} 8380 -2220 0 0 {name=r29 node=v(@m.xm3.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8380 -1950 2 1 {name=r30 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 8630 -2170 0 1 {name=M99
W=1.5
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8610 -1990 2 0 {name=p112 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/pfet_01v8.sym} 12990 -6100 0 1 {name=M100
W=2
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14410 -3390 0 1 {name=M62
W=2
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
