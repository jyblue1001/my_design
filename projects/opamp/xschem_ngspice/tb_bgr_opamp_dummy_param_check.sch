v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 9540 -2120 10530 -1250 {flags=graph
y1=-0.00061
y2=0.94
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=v_err_amp_ref
color=7
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 10660 -2120 11650 -1250 {flags=graph
y1=1.238719
y2=1.2415337
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="6 7"
node="vin+
vin-"}
B 2 11780 -2120 12770 -1250 {flags=graph
y1=0.83
y2=0.98
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="6 7"
node="x
y"}
B 2 12900 -2120 13890 -1250 {flags=graph
y1=0.42
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="6 7"
node="vout+
vout-"}
B 2 10660 -1130 11650 -260 {flags=graph
y1=-0.002
y2=0.002
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node="\\"vin+ vin- -\\""}
B 2 11780 -1130 12770 -260 {flags=graph
y1=-0.13
y2=0.13
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node="\\"x y -\\""}
B 2 12900 -1130 13890 -260 {flags=graph
y1=-0.87
y2=0.87
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=6
node="\\"vout+ vout- -\\""}
B 2 10660 -130 11650 740 {flags=graph,unlocked

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=8.3e-06













color="6 7 11 9 17 10"
node="v_err_gate
pfet_gate_10ua
nfet_gate_10ua
vb1
vb2
vb3"}
B 2 11780 -130 12770 740 {flags=graph
y1=0.22
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="6 7 11 17"
node="v_cmfb_s1
v_cmfb_s2
v_cmfb_s3
v_cmfb_s4"}
B 2 12910 -130 13900 740 {flags=graph
y1=2.2e-05
y2=2.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="6 7 11 17"
node="i(@m.xm82.msky130_fd_pr__pfet_01v8[id])
i(@m.xm84.msky130_fd_pr__nfet_01v8[id])
i(@m.xm85.msky130_fd_pr__pfet_01v8[id])
i(@m.xm76.msky130_fd_pr__nfet_01v8[id])"}
B 2 12910 860 13900 1730 {flags=graph
y1=0
y2=4.4e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm82.msky130_fd_pr__pfet_01v8[id])}
B 2 12910 1850 13900 2720 {flags=graph
y1=2.2e-05
y2=2.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm84.msky130_fd_pr__nfet_01v8[id])}
B 2 12910 2840 13900 3710 {flags=graph
y1=2.2e-05
y2=2.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm85.msky130_fd_pr__pfet_01v8[id])}
B 2 12910 3830 13900 4700 {flags=graph
y1=2.2e-05
y2=2.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm76.msky130_fd_pr__nfet_01v8[id])}
B 2 14060 -130 15050 740 {flags=graph
y1=4.2e-07
y2=4e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="6 7 11 17"
node="i(@m.xm26.msky130_fd_pr__pfet_01v8[id])
i(@m.xm25.msky130_fd_pr__nfet_01v8[id])
i(@m.xm28.msky130_fd_pr__pfet_01v8[id])
i(@m.xm27.msky130_fd_pr__nfet_01v8[id])"}
B 2 14060 860 15050 1730 {flags=graph
y1=9.9e-07
y2=3.5e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm26.msky130_fd_pr__pfet_01v8[id])}
B 2 14060 1850 15050 2720 {flags=graph
y1=1.3e-06
y2=5.6e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm25.msky130_fd_pr__nfet_01v8[id])}
B 2 14060 2840 15050 3710 {flags=graph
y1=9.9e-07
y2=3.5e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm28.msky130_fd_pr__pfet_01v8[id])}
B 2 14060 3830 15050 4700 {flags=graph
y1=1.3e-06
y2=5.6e-06
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.xm27.msky130_fd_pr__nfet_01v8[id])}
B 2 10660 890 11650 1760 {flags=graph,unlocked

y2=0.00011
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=8.2675113e-06
x2=2.7467511e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=2.2e-05














color="6 7 11 17 18"
node="i(@m.xm16.msky130_fd_pr__nfet_01v8[id])
i(@m.xm41.msky130_fd_pr__nfet_01v8[id])
i(@m.xm5.msky130_fd_pr__pfet_01v8[id])
i(@m.xm6.msky130_fd_pr__pfet_01v8[id])
i(@m.xm36.msky130_fd_pr__pfet_01v8[id])"}
B 2 11780 890 12770 1760 {flags=graph,unlocked

y2=0.00089
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=8.2675113e-06
x2=2.7467511e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.00088














color=6
node=i(@m.xm15.msky130_fd_pr__nfet_01v8[id])}
B 2 15210 -130 16200 740 {flags=graph
y1=1.420257
y2=1.4281734
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="6 7"
node="vd3
vd4"}
B 2 15210 860 16200 1730 {flags=graph
y1=0.81
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="6 7"
node="x
y"}
B 2 15210 1850 16200 2720 {flags=graph
y1=0.53901977
y2=0.55181977
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="6 7"
node="vd1
vd2"}
B 2 14060 -1130 15050 -260 {flags=graph
y1=0.91008618
y2=0.91043802
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color=6
node=v_tot}
B 2 15210 -1130 16200 -260 {flags=graph
y1=0.89493213
y2=0.89493217
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color=6
node=v_err_amp_ref}
B 2 16550 1850 17540 2720 {flags=graph
y1=-6.3e-10
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="6 7 11 17"
node="vin-
vd1
x
VOUT-"}
B 2 17790 1850 18780 2720 {flags=graph
y1=0.53774427
y2=0.55054427
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="6 7"
node="\\"vin- 0.697 -\\"
vd1"}
B 2 19020 1850 20010 2720 {flags=graph
y1=0.47
y2=0.62
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="7 11"
node="vd1
\\"x 0.36 -\\""}
B 2 16550 2940 17540 3810 {flags=graph
y1=-6.3e-10
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="6 7 11 17"
node="vin+
vd2
y
VOUT+"}
B 2 17790 2940 18780 3810 {flags=graph
y1=0.53774427
y2=0.55054427
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="6 7"
node="\\"vin+ 0.697 -\\"
vd2"}
B 2 19020 2940 20010 3810 {flags=graph
y1=0.47
y2=0.62
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=4.3592799e-06
x2=2.835928e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


color="7 11"
node="vd2
\\"y 0.36 -\\""}
T {N 30uA} 14470 -5460 0 0 1 1 {}
T {P 30uA} 14490 -6150 0 0 1 1 {}
T {P 30uA} 16590 -6150 0 1 1 1 {}
T {N 30uA} 16610 -5460 0 1 1 1 {}
T {1st stage pmos current source load voltage bias references} 1790 -6760 0 0 2 2 {}
T {1st stage} 9830 -7190 0 0 4 4 {}
T {1st gain stage} 8780 -6490 0 0 2 2 {}
T {1st stage CMFB} 13370 -6570 0 0 2 2 {}
T {2nd stage} 18810 -6990 0 0 4 4 {}
N 9750 -9320 9750 -9120 {lab=GND}
N 9750 -10170 9750 -10010 {
lab=VDD}
N 9750 -9980 9790 -9980 {lab=VDD}
N 9790 -10050 9790 -9980 {lab=VDD}
N 9750 -10050 9790 -10050 {lab=VDD}
N 9750 -9860 9850 -9860 {lab=V_err_amp_ref}
N 9750 -9950 9750 -9380 {lab=V_err_amp_ref}
N 10500 -9840 10540 -9840 {lab=VDD}
N 10540 -9910 10540 -9840 {lab=VDD}
N 10500 -9910 10540 -9910 {lab=VDD}
N 10310 -9840 10460 -9840 {lab=PFET_GATE_10uA}
N 10130 -9820 10180 -9820 {lab=V_CUR_REF_REG}
N 10130 -9820 10130 -9560 {lab=V_CUR_REF_REG}
N 10130 -9560 10500 -9560 {lab=V_CUR_REF_REG}
N 10500 -9810 10500 -9380 {lab=V_CUR_REF_REG}
N 9850 -9860 10180 -9860 {lab=V_err_amp_ref}
N 9750 -10170 10500 -10170 {lab=VDD}
N 10500 -10170 10500 -9870 {lab=VDD}
N 9750 -9120 10500 -9120 {lab=GND}
N 10500 -9320 10500 -9120 {lab=GND}
N 10400 -9840 10400 -9740 {lab=PFET_GATE_10uA}
N 10400 -9740 10890 -9740 {lab=PFET_GATE_10uA}
N 9480 -10050 9480 -9980 {lab=V_TOP}
N 9480 -10170 9480 -10110 {lab=VDD}
N 9340 -10170 9750 -10170 {lab=VDD}
N 8550 -9120 8930 -9120 {
lab=GND}
N 8510 -9200 8510 -9120 {
lab=GND}
N 8890 -9200 8890 -9120 {
lab=GND}
N 8510 -9120 8550 -9120 {
lab=GND}
N 8590 -10060 8730 -10060 {
lab=V_TOP}
N 8730 -10060 8890 -10060 {
lab=V_TOP}
N 8550 -10170 8550 -10090 {
lab=VDD}
N 8550 -10170 8930 -10170 {
lab=VDD}
N 8930 -10170 8930 -10090 {
lab=VDD}
N 8930 -9320 8930 -9230 {lab=Vbe2}
N 9190 -9320 9190 -9120 {lab=GND}
N 8310 -9320 8310 -9120 {lab=GND}
N 8930 -10060 8970 -10060 {lab=VDD}
N 8970 -10130 8970 -10060 {lab=VDD}
N 8930 -10130 8970 -10130 {lab=VDD}
N 8510 -10060 8550 -10060 {lab=VDD}
N 8510 -10130 8510 -10060 {lab=VDD}
N 8510 -10130 8550 -10130 {lab=VDD}
N 8310 -9120 8510 -9120 {lab=GND}
N 8930 -9170 8930 -9120 {lab=GND}
N 8550 -9170 8550 -9120 {lab=GND}
N 7790 -10060 7790 -9980 {lab=V_TOP}
N 7540 -9920 7540 -9790 {lab=START_UP}
N 7540 -10170 7540 -10090 {
lab=VDD}
N 7500 -10060 7540 -10060 {lab=VDD}
N 7500 -10130 7500 -10060 {lab=VDD}
N 7500 -10130 7540 -10130 {lab=VDD}
N 7540 -10030 7540 -9920 {lab=START_UP}
N 7540 -10170 8550 -10170 {lab=VDD}
N 7790 -10060 8350 -10060 {lab=V_TOP}
N 8350 -10060 8350 -10010 {lab=V_TOP}
N 8350 -10010 8670 -10010 {lab=V_TOP}
N 7540 -9950 7750 -9950 {lab=START_UP}
N 7540 -9120 8310 -9120 {lab=GND}
N 8670 -10060 8670 -10010 {lab=V_TOP}
N 7790 -9750 8550 -9750 {lab=bgr_Vin-}
N 7500 -9760 7500 -9690 {lab=GND}
N 7500 -9760 7540 -9760 {lab=GND}
N 7540 -9200 7540 -9120 {lab=GND}
N 7790 -9950 7830 -9950 {lab=VDD}
N 7540 -9380 7540 -9200 {lab=GND}
N 7580 -10060 7790 -10060 {lab=V_TOP}
N 7540 -9820 7600 -9820 {lab=START_UP}
N 7600 -9820 7600 -9760 {lab=START_UP}
N 7580 -9760 7600 -9760 {lab=START_UP}
N 7790 -9920 7790 -9750 {lab=bgr_Vin-}
N 8310 -9530 8310 -9380 {lab=bgr_Vin-}
N 9190 -9530 9190 -9380 {lab=bgr_Vin+}
N 8740 -9120 8740 -9050 {lab=GND}
N 8250 -9350 8290 -9350 {lab=GND}
N 8870 -9350 8910 -9350 {lab=GND}
N 9210 -9350 9250 -9350 {lab=GND}
N 8650 -9720 8670 -9720 {lab=GND}
N 8790 -9720 8810 -9720 {lab=VDD}
N 7830 -10170 7830 -9950 {lab=VDD}
N 8750 -9660 8750 -9530 {lab=bgr_Vin+}
N 8710 -9660 8710 -9530 {lab=bgr_Vin-}
N 8750 -9530 9190 -9530 {lab=bgr_Vin+}
N 8310 -9530 8710 -9530 {lab=bgr_Vin-}
N 8730 -10060 8730 -9790 {lab=V_TOP}
N 8930 -9530 8930 -9380 {lab=bgr_Vin+}
N 8930 -10030 8930 -9530 {lab=bgr_Vin+}
N 8550 -9530 8550 -9230 {lab=bgr_Vin-}
N 8550 -10030 8550 -9530 {lab=bgr_Vin-}
N 7500 -9340 7540 -9340 {lab=GND}
N 7500 -9410 7500 -9340 {lab=GND}
N 7500 -9410 7540 -9410 {lab=GND}
N 7540 -9470 7600 -9470 {lab=START_UP_NFET1}
N 7600 -9470 7600 -9410 {lab=START_UP_NFET1}
N 7580 -9410 7600 -9410 {lab=START_UP_NFET1}
N 7540 -9730 7540 -9440 {lab=START_UP_NFET1}
N 8930 -9120 9190 -9120 {lab=GND}
N 9190 -9120 9750 -9120 {lab=GND}
N 8930 -10170 9340 -10170 {lab=VDD}
N 8830 -9980 9710 -9980 {lab=V_TOP}
N 8830 -10060 8830 -9980 {lab=V_TOP}
N 9770 -9350 9810 -9350 {lab=GND}
N 10440 -9350 10480 -9350 {lab=GND}
N 10130 -10000 10130 -9860 {lab=V_err_amp_ref}
N 10130 -10000 14600 -10000 {lab=V_err_amp_ref}
N 8740 -10240 8740 -10170 {lab=VDD}
N 11210 -9840 11250 -9840 {lab=VDD}
N 11250 -9910 11250 -9840 {lab=VDD}
N 11210 -9910 11250 -9910 {lab=VDD}
N 11210 -9240 11210 -9120 {lab=GND}
N 11160 -9210 11210 -9210 {lab=GND}
N 11160 -9270 11160 -9210 {lab=GND}
N 11160 -9270 11210 -9270 {lab=GND}
N 11280 -9340 11280 -9270 {lab=NFET_GATE_10uA}
N 11210 -9340 11280 -9340 {lab=NFET_GATE_10uA}
N 11250 -9270 11740 -9270 {lab=NFET_GATE_10uA}
N 11210 -9810 11210 -9300 {lab=NFET_GATE_10uA}
N 10500 -9120 11210 -9120 {lab=GND}
N 10500 -10170 11210 -10170 {lab=VDD}
N 11210 -10170 11210 -9870 {lab=VDD}
N 10890 -9840 11170 -9840 {lab=PFET_GATE_10uA}
N 10890 -9840 10890 -9740 {lab=PFET_GATE_10uA}
N 11930 -9240 11930 -9120 {lab=GND}
N 11930 -9210 11980 -9210 {lab=GND}
N 11980 -9270 11980 -9210 {lab=GND}
N 11930 -9270 11980 -9270 {lab=GND}
N 11930 -9470 11930 -9300 {lab=Vb2}
N 11820 -9270 11890 -9270 {lab=NFET_GATE_10uA}
N 12530 -9240 12530 -9120 {lab=GND}
N 12530 -9210 12580 -9210 {lab=GND}
N 12580 -9270 12580 -9210 {lab=GND}
N 12530 -9270 12580 -9270 {lab=GND}
N 12530 -9470 12530 -9300 {lab=Vb3}
N 12420 -9270 12490 -9270 {lab=NFET_GATE_10uA}
N 11740 -9270 11820 -9270 {lab=NFET_GATE_10uA}
N 11210 -9120 11930 -9120 {lab=GND}
N 11930 -9120 12530 -9120 {lab=GND}
N 11780 -9350 11780 -9270 {lab=NFET_GATE_10uA}
N 12420 -9350 12420 -9270 {lab=NFET_GATE_10uA}
N 11930 -9840 11980 -9840 {lab=VDD}
N 11980 -9900 11980 -9840 {lab=VDD}
N 11930 -9900 11980 -9900 {lab=VDD}
N 11760 -9840 11890 -9840 {lab=PFET_GATE_10uA}
N 11930 -10170 11930 -9870 {lab=VDD}
N 11210 -10170 11930 -10170 {lab=VDD}
N 11110 -9840 11110 -9740 {lab=PFET_GATE_10uA}
N 11110 -9740 11760 -9740 {lab=PFET_GATE_10uA}
N 11760 -9840 11760 -9740 {lab=PFET_GATE_10uA}
N 11930 -9810 11930 -9620 {lab=Vb1}
N 13150 -9210 13200 -9210 {lab=GND}
N 13200 -9270 13200 -9210 {lab=GND}
N 13150 -9270 13200 -9270 {lab=GND}
N 13040 -9270 13110 -9270 {lab=NFET_GATE_10uA}
N 13040 -9350 13040 -9270 {lab=NFET_GATE_10uA}
N 13150 -9470 13150 -9300 {lab=V_err_gate}
N 13150 -9240 13150 -9120 {lab=GND}
N 13570 -9210 13620 -9210 {lab=GND}
N 13620 -9270 13620 -9210 {lab=GND}
N 13570 -9270 13620 -9270 {lab=GND}
N 13460 -9270 13530 -9270 {lab=NFET_GATE_10uA}
N 13460 -9350 13460 -9270 {lab=NFET_GATE_10uA}
N 13570 -9470 13570 -9300 {lab=V_CMFB_S2}
N 13570 -9240 13570 -9120 {lab=GND}
N 13150 -9840 13200 -9840 {lab=VDD}
N 13200 -9900 13200 -9840 {lab=VDD}
N 13150 -9900 13200 -9900 {lab=VDD}
N 12980 -9840 13110 -9840 {lab=PFET_GATE_10uA}
N 13150 -10170 13150 -9870 {lab=VDD}
N 12980 -9840 12980 -9740 {lab=PFET_GATE_10uA}
N 13150 -9810 13150 -9620 {lab=V_tail_gate}
N 11760 -9740 12360 -9740 {lab=PFET_GATE_10uA}
N 11930 -10170 12530 -10170 {lab=VDD}
N 11780 -9350 12420 -9350 {lab=NFET_GATE_10uA}
N 11370 -9840 11410 -9840 {lab=VDD}
N 11370 -9910 11370 -9840 {lab=VDD}
N 11370 -9910 11410 -9910 {lab=VDD}
N 11410 -10170 11410 -9870 {lab=VDD}
N 11410 -9910 11490 -9910 {lab=VDD}
N 11490 -9910 11490 -9840 {lab=VDD}
N 11450 -9840 11490 -9840 {lab=VDD}
N 11410 -9810 11410 -9780 {lab=NFET_GATE_10uA}
N 11210 -9780 11410 -9780 {lab=NFET_GATE_10uA}
N 11030 -9240 11030 -9120 {lab=GND}
N 11030 -9210 11080 -9210 {lab=GND}
N 11080 -9270 11080 -9210 {lab=GND}
N 11030 -9270 11080 -9270 {lab=GND}
N 10950 -9270 10990 -9270 {lab=GND}
N 10950 -9210 11030 -9210 {lab=GND}
N 10950 -9270 10950 -9210 {lab=GND}
N 11030 -9340 11210 -9340 {lab=NFET_GATE_10uA}
N 11030 -9340 11030 -9300 {lab=NFET_GATE_10uA}
N 10660 -9840 10700 -9840 {lab=VDD}
N 10660 -9910 10660 -9840 {lab=VDD}
N 10660 -9910 10700 -9910 {lab=VDD}
N 10700 -10170 10700 -9870 {lab=VDD}
N 10700 -9910 10780 -9910 {lab=VDD}
N 10780 -9910 10780 -9840 {lab=VDD}
N 10740 -9840 10780 -9840 {lab=VDD}
N 10700 -9810 10700 -9780 {lab=V_CUR_REF_REG}
N 10500 -9780 10700 -9780 {lab=V_CUR_REF_REG}
N 12710 -9240 12710 -9120 {lab=GND}
N 12660 -9210 12710 -9210 {lab=GND}
N 12660 -9270 12660 -9210 {lab=GND}
N 12660 -9270 12710 -9270 {lab=GND}
N 12750 -9270 12790 -9270 {lab=GND}
N 12710 -9210 12790 -9210 {lab=GND}
N 12790 -9270 12790 -9210 {lab=GND}
N 12530 -9390 12710 -9390 {lab=Vb3}
N 12710 -9390 12710 -9300 {lab=Vb3}
N 12530 -9120 12710 -9120 {lab=GND}
N 13150 -9120 13570 -9120 {lab=GND}
N 13570 -9840 13620 -9840 {lab=VDD}
N 13620 -9900 13620 -9840 {lab=VDD}
N 13570 -9900 13620 -9900 {lab=VDD}
N 13400 -9840 13530 -9840 {lab=PFET_GATE_10uA}
N 13570 -10170 13570 -9870 {lab=VDD}
N 13400 -9840 13400 -9740 {lab=PFET_GATE_10uA}
N 13570 -9810 13570 -9620 {lab=V_CMFB_S1}
N 12360 -9740 13400 -9740 {lab=PFET_GATE_10uA}
N 12530 -10170 13570 -10170 {lab=VDD}
N 7500 -9690 7500 -9410 {lab=GND}
N 9980 -10170 9980 -10010 {
lab=VDD}
N 9980 -9980 10020 -9980 {lab=VDD}
N 10020 -10050 10020 -9980 {lab=VDD}
N 9980 -10050 10020 -10050 {lab=VDD}
N 9890 -9980 9940 -9980 {lab=VDD}
N 9890 -10050 9890 -9980 {lab=VDD}
N 9890 -10050 9980 -10050 {lab=VDD}
N 9750 -9910 9980 -9910 {lab=V_err_amp_ref}
N 14140 -9210 14190 -9210 {lab=GND}
N 14190 -9270 14190 -9210 {lab=GND}
N 14140 -9270 14190 -9270 {lab=GND}
N 14140 -9240 14140 -9120 {lab=GND}
N 13570 -9120 14140 -9120 {lab=GND}
N 14140 -9470 14140 -9300 {lab=V_CMFB_S4}
N 14020 -9350 14020 -9270 {lab=NFET_GATE_10uA}
N 14020 -9270 14100 -9270 {lab=NFET_GATE_10uA}
N 14140 -9840 14190 -9840 {lab=VDD}
N 14190 -9900 14190 -9840 {lab=VDD}
N 14140 -9900 14190 -9900 {lab=VDD}
N 13970 -9840 14100 -9840 {lab=PFET_GATE_10uA}
N 14140 -10170 14140 -9870 {lab=VDD}
N 13970 -9840 13970 -9740 {lab=PFET_GATE_10uA}
N 14140 -9810 14140 -9620 {lab=V_CMFB_S3}
N 12420 -9350 13040 -9350 {lab=NFET_GATE_10uA}
N 13040 -9350 13460 -9350 {lab=NFET_GATE_10uA}
N 13460 -9350 14020 -9350 {lab=NFET_GATE_10uA}
N 13750 -9240 13750 -9120 {lab=GND}
N 13700 -9210 13750 -9210 {lab=GND}
N 13700 -9270 13700 -9210 {lab=GND}
N 13700 -9270 13750 -9270 {lab=GND}
N 13790 -9270 13830 -9270 {lab=GND}
N 13750 -9210 13830 -9210 {lab=GND}
N 13830 -9270 13830 -9210 {lab=GND}
N 13570 -9390 13750 -9390 {lab=V_CMFB_S2}
N 13750 -9390 13750 -9300 {lab=V_CMFB_S2}
N 14320 -9240 14320 -9120 {lab=GND}
N 14270 -9210 14320 -9210 {lab=GND}
N 14270 -9270 14270 -9210 {lab=GND}
N 14270 -9270 14320 -9270 {lab=GND}
N 14360 -9270 14400 -9270 {lab=GND}
N 14320 -9210 14400 -9210 {lab=GND}
N 14400 -9270 14400 -9210 {lab=GND}
N 14140 -9390 14320 -9390 {lab=V_CMFB_S4}
N 14320 -9390 14320 -9300 {lab=V_CMFB_S4}
N 14140 -9120 14320 -9120 {lab=GND}
N 12110 -9240 12110 -9120 {lab=GND}
N 12060 -9210 12110 -9210 {lab=GND}
N 12060 -9270 12060 -9210 {lab=GND}
N 12060 -9270 12110 -9270 {lab=GND}
N 12150 -9270 12190 -9270 {lab=GND}
N 12110 -9210 12190 -9210 {lab=GND}
N 12190 -9270 12190 -9210 {lab=GND}
N 11930 -9390 12110 -9390 {lab=Vb2}
N 12110 -9390 12110 -9300 {lab=Vb2}
N 13730 -9840 13770 -9840 {lab=VDD}
N 13730 -9910 13730 -9840 {lab=VDD}
N 13730 -9910 13770 -9910 {lab=VDD}
N 13770 -10170 13770 -9870 {lab=VDD}
N 13770 -9910 13850 -9910 {lab=VDD}
N 13850 -9910 13850 -9840 {lab=VDD}
N 13810 -9840 13850 -9840 {lab=VDD}
N 13770 -9810 13770 -9780 {lab=V_CMFB_S1}
N 13570 -9780 13770 -9780 {lab=V_CMFB_S1}
N 14300 -9840 14340 -9840 {lab=VDD}
N 14300 -9910 14300 -9840 {lab=VDD}
N 14300 -9910 14340 -9910 {lab=VDD}
N 14340 -10170 14340 -9870 {lab=VDD}
N 14340 -9910 14420 -9910 {lab=VDD}
N 14420 -9910 14420 -9840 {lab=VDD}
N 14380 -9840 14420 -9840 {lab=VDD}
N 14340 -9810 14340 -9780 {lab=V_CMFB_S3}
N 14140 -9780 14340 -9780 {lab=V_CMFB_S3}
N 14140 -10170 14340 -10170 {lab=VDD}
N 12090 -9840 12130 -9840 {lab=VDD}
N 12090 -9910 12090 -9840 {lab=VDD}
N 12090 -9910 12130 -9910 {lab=VDD}
N 12130 -10170 12130 -9870 {lab=VDD}
N 12130 -9910 12210 -9910 {lab=VDD}
N 12210 -9910 12210 -9840 {lab=VDD}
N 12170 -9840 12210 -9840 {lab=VDD}
N 12130 -9810 12130 -9780 {lab=Vb1}
N 11930 -9780 12130 -9780 {lab=Vb1}
N 12710 -9120 13150 -9120 {lab=GND}
N 9980 -9950 9980 -9910 {lab=V_err_amp_ref}
N 8000 -9920 8000 -9850 {lab=V_TOP}
N 7830 -9950 8000 -9950 {lab=VDD}
N 8000 -10170 8000 -9980 {lab=VDD}
N 8040 -9950 8080 -9950 {lab=VDD}
N 8080 -10030 8080 -9950 {lab=VDD}
N 8000 -10030 8080 -10030 {lab=VDD}
N 7790 -10010 7890 -10010 {lab=V_TOP}
N 7890 -10010 7890 -9850 {lab=V_TOP}
N 7890 -9850 8000 -9850 {lab=V_TOP}
N 13570 -10170 14140 -10170 {lab=VDD}
N 13400 -9740 13970 -9740 {lab=PFET_GATE_10uA}
N 8740 -4420 8740 -4330 {lab=V_p}
N 8740 -4330 9490 -4330 {lab=V_p}
N 9490 -4420 9490 -4330 {lab=V_p}
N 8740 -5030 8740 -4480 {lab=VD1}
N 9490 -5030 9490 -4480 {lab=VD2}
N 8780 -5060 9450 -5060 {lab=Vb1}
N 8740 -5390 8740 -5090 {lab=X}
N 9490 -5390 9490 -5090 {lab=Y}
N 8740 -5810 8740 -5450 {lab=VD3}
N 9490 -5810 9490 -5450 {lab=VD4}
N 8780 -5420 9450 -5420 {lab=Vb2}
N 9490 -5420 9560 -5420 {lab=VD4}
N 9560 -5490 9560 -5420 {lab=VD4}
N 9490 -5490 9560 -5490 {lab=VD4}
N 8670 -5420 8740 -5420 {lab=VD3}
N 8670 -5490 8670 -5420 {lab=VD3}
N 8670 -5490 8740 -5490 {lab=VD3}
N 8740 -5990 8740 -5870 {lab=VDD}
N 9490 -5990 9490 -5870 {lab=VDD}
N 8780 -5840 9450 -5840 {lab=Vb3}
N 9490 -5840 9560 -5840 {lab=VDD}
N 9560 -5910 9560 -5840 {lab=VDD}
N 9490 -5910 9560 -5910 {lab=VDD}
N 8670 -5840 8740 -5840 {lab=VDD}
N 8670 -5910 8670 -5840 {lab=VDD}
N 8670 -5910 8740 -5910 {lab=VDD}
N 8740 -5990 9490 -5990 {lab=VDD}
N 8690 -5060 8740 -5060 {lab=GND}
N 8690 -5060 8690 -5000 {lab=GND}
N 8690 -5000 9550 -5000 {lab=GND}
N 9550 -5060 9550 -5000 {lab=GND}
N 9490 -5060 9550 -5060 {lab=GND}
N 8920 -6050 8920 -5990 {lab=VDD}
N 9190 -4450 9490 -4450 {lab=GND}
N 8740 -4450 9190 -4450 {lab=GND}
N 9040 -4330 9040 -4220 {lab=V_p}
N 9190 -4450 9190 -4190 {lab=GND}
N 9040 -4190 9190 -4190 {lab=GND}
N 9040 -4160 9040 -3670 {lab=GND}
N 9040 -4110 9190 -4110 {lab=GND}
N 9190 -4190 9190 -4110 {lab=GND}
N 9530 -4450 9620 -4450 {lab=VIN+}
N 6930 -4330 6930 -4220 {lab=V_p_mir}
N 6850 -4190 6930 -4190 {lab=GND}
N 6930 -4160 6930 -3950 {lab=GND}
N 6850 -4110 6930 -4110 {lab=GND}
N 6850 -4190 6850 -4110 {lab=GND}
N 6970 -4190 9000 -4190 {lab=V_tail_gate}
N 7010 -4450 7100 -4450 {lab=GND}
N 6770 -4450 7010 -4450 {lab=GND}
N 6770 -4420 6770 -4330 {lab=V_p_mir}
N 6770 -4330 7100 -4330 {lab=V_p_mir}
N 7100 -4420 7100 -4330 {lab=V_p_mir}
N 6850 -4450 6850 -4190 {lab=GND}
N 6770 -4600 6770 -4480 {lab=V_tail_gate}
N 6770 -4600 7100 -4600 {lab=V_tail_gate}
N 7100 -4600 7100 -4480 {lab=V_tail_gate}
N 6930 -4800 6930 -4600 {lab=V_tail_gate}
N 7140 -4450 7210 -4450 {lab=VIN-}
N 6660 -4450 6730 -4450 {lab=VIN+}
N 6930 -4720 7500 -4720 {lab=V_tail_gate}
N 7500 -4720 7500 -4190 {lab=V_tail_gate}
N 9040 -4710 9040 -4630 {lab=Vb1}
N 9040 -4600 9190 -4600 {lab=GND}
N 9040 -4570 9040 -4330 {lab=V_p}
N 9040 -5060 9040 -4770 {lab=Vb1}
N 8910 -4600 9000 -4600 {lab=Vb1}
N 8910 -4860 8910 -4600 {lab=Vb1}
N 8910 -4860 9040 -4860 {lab=Vb1}
N 9040 -5630 9040 -5060 {lab=Vb1}
N 14760 -5680 14760 -5630 {lab=VDD}
N 14760 -5470 14760 -5410 {lab=GND}
N 14760 -5570 14760 -5530 {lab=V_CMFB_S2}
N 14760 -5910 14760 -5860 {lab=GND}
N 14760 -6020 14760 -5970 {lab=V_CMFB_S1}
N 14640 -5940 14640 -5600 {lab=X}
N 16360 -5940 16450 -5940 {lab=Y}
N 16450 -5940 16450 -5600 {lab=Y}
N 16360 -5600 16450 -5600 {lab=Y}
N 14520 -5780 14640 -5780 {lab=X}
N 16450 -5780 16570 -5780 {lab=Y}
N 15690 -5990 16320 -5990 {lab=V_CMFB_S3}
N 15690 -5550 16320 -5550 {lab=V_CMFB_S4}
N 14760 -5940 14840 -5940 {lab=VDD}
N 14760 -6100 14840 -6100 {lab=VDD}
N 14760 -6150 14760 -6070 {lab=VDD}
N 14840 -6100 14840 -5940 {lab=VDD}
N 14760 -5440 14840 -5440 {lab=GND}
N 14760 -5600 14840 -5600 {lab=GND}
N 14840 -5600 14840 -5440 {lab=GND}
N 16320 -5680 16320 -5630 {lab=VDD}
N 16320 -5470 16320 -5410 {lab=GND}
N 16320 -5570 16320 -5530 {lab=V_CMFB_S4}
N 16320 -5910 16320 -5860 {lab=GND}
N 16320 -6020 16320 -5970 {lab=V_CMFB_S3}
N 16240 -5940 16320 -5940 {lab=VDD}
N 16240 -6100 16320 -6100 {lab=VDD}
N 16320 -6150 16320 -6070 {lab=VDD}
N 16240 -6100 16240 -5940 {lab=VDD}
N 16240 -5440 16320 -5440 {lab=GND}
N 16240 -5600 16320 -5600 {lab=GND}
N 16240 -5600 16240 -5440 {lab=GND}
N 15530 -5990 15530 -5550 {lab=V_tot}
N 13500 -4980 13500 -4910 {lab=V_err_p}
N 13260 -4980 13500 -4980 {lab=V_err_p}
N 13260 -4980 13260 -4910 {lab=V_err_p}
N 13380 -5240 13380 -4980 {lab=V_err_p}
N 13380 -5550 13380 -5300 {lab=VDD}
N 13500 -4850 13500 -3990 {lab=err_amp_mir}
N 13260 -4850 13260 -3990 {lab=err_amp_out}
N 13500 -3930 13500 -3850 {lab=GND}
N 13260 -3850 13500 -3850 {lab=GND}
N 13260 -3930 13260 -3850 {lab=GND}
N 13380 -3850 13380 -3800 {lab=GND}
N 13260 -4880 13500 -4880 {lab=VDD}
N 13300 -3960 13460 -3960 {lab=err_amp_mir}
N 13220 -3960 13260 -3960 {lab=GND}
N 13220 -3960 13220 -3910 {lab=GND}
N 13220 -3910 13260 -3910 {lab=GND}
N 13500 -3960 13540 -3960 {lab=GND}
N 13540 -3960 13540 -3910 {lab=GND}
N 13500 -3910 13540 -3910 {lab=GND}
N 13400 -4040 13500 -4040 {lab=err_amp_mir}
N 13400 -4040 13400 -3960 {lab=err_amp_mir}
N 15530 -5550 15530 -4880 {lab=V_tot}
N 13130 -4880 13220 -4880 {lab=V_err_amp_ref}
N 9190 -4190 9340 -4190 {lab=GND}
N 9190 -4110 9340 -4110 {lab=GND}
N 9340 -4160 9340 -4110 {lab=GND}
N 9340 -4330 9340 -4220 {lab=V_p}
N 13540 -4880 15530 -4880 {lab=V_tot}
N 13380 -5270 13420 -5270 {lab=VDD}
N 13420 -5330 13420 -5270 {lab=VDD}
N 13380 -5330 13420 -5330 {lab=VDD}
N 13420 -5270 13420 -4880 {lab=VDD}
N 11960 -5150 11960 -5080 {lab=V_err_mir_p}
N 11960 -5150 12200 -5150 {lab=V_err_mir_p}
N 12200 -5150 12200 -5080 {lab=V_err_mir_p}
N 12080 -5240 12080 -5150 {lab=V_err_mir_p}
N 12080 -5550 12080 -5300 {lab=VDD}
N 11960 -5050 12200 -5050 {lab=VDD}
N 12240 -5050 12330 -5050 {lab=V_err_amp_ref}
N 12040 -5270 12080 -5270 {lab=VDD}
N 12040 -5330 12040 -5270 {lab=VDD}
N 12040 -5330 12080 -5330 {lab=VDD}
N 12040 -5270 12040 -5050 {lab=VDD}
N 12120 -5270 13340 -5270 {lab=V_err_gate}
N 11960 -5020 11960 -4960 {lab=V_err_gate}
N 11960 -4960 12200 -4960 {lab=V_err_gate}
N 12200 -5020 12200 -4960 {lab=V_err_gate}
N 12080 -4960 12080 -4720 {lab=V_err_gate}
N 11830 -5050 11920 -5050 {lab=V_tot}
N 12530 -5270 12530 -4900 {lab=V_err_gate}
N 12080 -4900 12530 -4900 {lab=V_err_gate}
N 9380 -4190 13110 -4190 {lab=err_amp_out}
N 13110 -4190 13260 -4190 {lab=err_amp_out}
N 9190 -4740 9190 -4450 {lab=GND}
N 9190 -5000 9190 -4740 {lab=GND}
N 18830 -5510 18830 -4870 {lab=VOUT-}
N 19900 -5510 19900 -4870 {lab=VOUT+}
N 19900 -5540 19970 -5540 {lab=VDD}
N 19970 -5610 19970 -5540 {lab=VDD}
N 19900 -5610 19970 -5610 {lab=VDD}
N 18760 -5540 18830 -5540 {lab=VDD}
N 18760 -5610 18830 -5610 {lab=VDD}
N 18760 -5610 18760 -5540 {lab=VDD}
N 18830 -5690 18830 -5570 {lab=VDD}
N 19900 -5690 19900 -5570 {lab=VDD}
N 18830 -4810 18830 -4640 {lab=GND}
N 19900 -4810 19900 -4640 {lab=GND}
N 19900 -4770 19970 -4770 {lab=GND}
N 19970 -4840 19970 -4770 {lab=GND}
N 19900 -4840 19970 -4840 {lab=GND}
N 18760 -4770 18830 -4770 {lab=GND}
N 18760 -4840 18830 -4840 {lab=GND}
N 18760 -4840 18760 -4770 {lab=GND}
N 18870 -5540 19200 -5540 {lab=X}
N 19530 -5540 19860 -5540 {lab=Y}
N 18590 -5150 18830 -5150 {lab=VOUT-}
N 19900 -5150 20150 -5150 {lab=VOUT+}
N 19770 -4960 19900 -4960 {lab=VOUT+}
N 19370 -4840 19860 -4840 {lab=V_b_2nd_stage}
N 19430 -4960 19710 -4960 {lab=V_b_2nd_stage}
N 19430 -4960 19430 -4840 {lab=V_b_2nd_stage}
N 18830 -4960 18960 -4960 {lab=VOUT-}
N 19020 -4960 19310 -4960 {lab=V_b_2nd_stage}
N 18870 -4840 19370 -4840 {lab=V_b_2nd_stage}
N 19310 -4960 19310 -4840 {lab=V_b_2nd_stage}
N 15430 -5550 15630 -5550 {lab=V_tot}
N 15430 -5990 15630 -5990 {lab=V_tot}
N 14760 -5990 15370 -5990 {lab=V_CMFB_S1}
N 14760 -5550 15370 -5550 {lab=V_CMFB_S2}
N 14640 -5940 14720 -5940 {lab=X}
N 14640 -5600 14720 -5600 {lab=X}
N 8570 -4450 8700 -4450 {lab=VIN-}
N 16320 -5550 16440 -5550 {lab=V_CMFB_S4}
N 16320 -5990 16430 -5990 {lab=V_CMFB_S3}
N 8740 -4330 9490 -4330 {lab=V_p}
N 7760 -4450 8570 -4450 {lab=VIN-}
N 7210 -4450 7760 -4450 {lab=VIN-}
N 6660 -4550 7760 -4550 {lab=VIN+}
N 6660 -4550 6660 -4450 {lab=VIN+}
N 9620 -4550 9620 -4450 {lab=VIN+}
N 7760 -4550 9620 -4550 {lab=VIN+}
N 8570 -4390 8570 -4320 {lab=VIN-}
N 9620 -4390 9620 -4320 {lab=VIN+}
N 6930 -4990 6930 -4800 {lab=V_tail_gate}
N 2710 -5980 2710 -5860 {lab=Vb2}
N 3490 -6180 3490 -6020 {lab=Vb2_Vb3}
N 3420 -5990 3490 -5990 {lab=Vb2_Vb3}
N 3420 -6060 3420 -5990 {lab=Vb2_Vb3}
N 3420 -6060 3490 -6060 {lab=Vb2_Vb3}
N 2640 -6010 2710 -6010 {lab=VDD}
N 2640 -6080 2640 -6010 {lab=VDD}
N 2640 -6080 2710 -6080 {lab=VDD}
N 3490 -6360 3490 -6240 {lab=VDD}
N 3420 -6210 3490 -6210 {lab=VDD}
N 3420 -6280 3420 -6210 {lab=VDD}
N 3420 -6280 3490 -6280 {lab=VDD}
N 3070 -6450 3070 -6360 {lab=VDD}
N 2710 -6360 3490 -6360 {lab=VDD}
N 2750 -6010 2830 -6010 {lab=Vb2}
N 3530 -6210 3610 -6210 {lab=Vb3}
N 3610 -6210 3610 -5890 {lab=Vb3}
N 3490 -5890 3610 -5890 {lab=Vb3}
N 2710 -5910 2830 -5910 {lab=Vb2}
N 3530 -5990 3690 -5990 {lab=Vb2}
N 2830 -6010 2830 -5910 {lab=Vb2}
N 2710 -6360 2710 -6040 {lab=VDD}
N 9040 -4770 9040 -4710 {lab=Vb1}
N 14640 -5550 14760 -5550 {lab=V_CMFB_S2}
N 14640 -5990 14760 -5990 {lab=V_CMFB_S1}
N 2710 -5860 2710 -5760 {lab=Vb2}
N 8570 -4450 8570 -4390 {lab=VIN-}
N 9620 -4450 9620 -4390 {lab=VIN+}
N 19580 -5540 19580 -5460 {lab=Y}
N 19150 -5540 19150 -5460 {lab=X}
N 19760 -5310 19900 -5310 {lab=VOUT+}
N 18830 -5310 18970 -5310 {lab=VOUT-}
N 19580 -5400 19580 -5310 {lab=cap_res_Y}
N 19150 -5400 19150 -5310 {lab=cap_res_X}
N 19030 -5310 19150 -5310 {lab=cap_res_X}
N 19580 -5310 19700 -5310 {lab=cap_res_Y}
N 2300 -6360 2300 -6230 {lab=VDD}
N 2300 -6360 2710 -6360 {lab=VDD}
N 2300 -6200 2370 -6200 {lab=VDD}
N 2370 -6280 2370 -6200 {lab=VDD}
N 2300 -6280 2370 -6280 {lab=VDD}
N 2210 -6280 2210 -6200 {lab=VDD}
N 2210 -6280 2300 -6280 {lab=VDD}
N 2300 -6170 2300 -6120 {lab=VDD}
N 2460 -5940 2510 -5940 {lab=VDD}
N 2510 -6000 2510 -5940 {lab=VDD}
N 2460 -6000 2510 -6000 {lab=VDD}
N 2410 -5940 2420 -5940 {lab=VDD}
N 2410 -6000 2410 -5940 {lab=VDD}
N 2410 -6000 2460 -6000 {lab=VDD}
N 2460 -5910 2460 -5870 {lab=Vb2}
N 2460 -6000 2460 -5970 {lab=VDD}
N 2460 -5870 2710 -5870 {lab=Vb2}
N 2460 -6360 2460 -6000 {lab=VDD}
N 3860 -6210 3930 -6210 {lab=VDD}
N 3860 -6280 3860 -6210 {lab=VDD}
N 3860 -6280 3930 -6280 {lab=VDD}
N 3930 -6320 3930 -6240 {lab=VDD}
N 3490 -6320 3930 -6320 {lab=VDD}
N 3970 -6210 4010 -6210 {lab=VDD}
N 4010 -6260 4010 -6210 {lab=VDD}
N 3930 -6260 4010 -6260 {lab=VDD}
N 3490 -6150 3930 -6150 {lab=Vb2_Vb3}
N 3930 -6180 3930 -6150 {lab=Vb2_Vb3}
N 3860 -5990 3930 -5990 {lab=Vb2_Vb3}
N 3860 -6060 3860 -5990 {lab=Vb2_Vb3}
N 3860 -6060 3930 -6060 {lab=Vb2_Vb3}
N 3930 -6110 3930 -6020 {lab=Vb2_Vb3}
N 3970 -5990 4010 -5990 {lab=Vb2_Vb3}
N 4010 -6040 4010 -5990 {lab=Vb2_Vb3}
N 3930 -6040 4010 -6040 {lab=Vb2_Vb3}
N 3490 -6110 3930 -6110 {lab=Vb2_Vb3}
N 3930 -5960 3930 -5840 {lab=Vb3}
N 3490 -5840 3930 -5840 {lab=Vb3}
N 7100 -4020 7100 -3990 {lab=GND}
N 7020 -4050 7100 -4050 {lab=GND}
N 7020 -4050 7020 -3990 {lab=GND}
N 6930 -3990 7100 -3990 {lab=GND}
N 7100 -4110 7100 -4080 {lab=GND}
N 6930 -4110 7100 -4110 {lab=GND}
N 7140 -4050 7180 -4050 {lab=GND}
N 7180 -4050 7180 -3990 {lab=GND}
N 7100 -3990 7180 -3990 {lab=GND}
N 9540 -4060 9540 -3760 {lab=GND}
N 9040 -3760 9540 -3760 {lab=GND}
N 9440 -4090 9540 -4090 {lab=GND}
N 9440 -4090 9440 -3760 {lab=GND}
N 9580 -4090 9660 -4090 {lab=GND}
N 9660 -4090 9660 -3760 {lab=GND}
N 9540 -3760 9660 -3760 {lab=GND}
N 9540 -4280 9540 -4120 {lab=V_p}
N 9340 -4280 9540 -4280 {lab=V_p}
N 6310 -4450 6440 -4450 {lab=GND}
N 6310 -4600 6310 -4480 {lab=V_tail_gate}
N 6310 -4600 6770 -4600 {lab=V_tail_gate}
N 6170 -4450 6270 -4450 {lab=GND}
N 6170 -4450 6170 -4360 {lab=GND}
N 6170 -4360 6310 -4360 {lab=GND}
N 6310 -4190 6850 -4190 {lab=GND}
N 6310 -4420 6310 -4190 {lab=GND}
N 6440 -4450 6440 -4190 {lab=GND}
N 8090 -3950 8160 -3950 {lab=GND}
N 8090 -3950 8090 -3860 {lab=GND}
N 8090 -3860 8200 -3860 {lab=GND}
N 8200 -4650 8200 -3980 {lab=VD1}
N 10070 -3950 10140 -3950 {lab=GND}
N 10140 -3950 10140 -3860 {lab=GND}
N 10030 -3860 10140 -3860 {lab=GND}
N 10030 -4650 10030 -3980 {lab=VD2}
N 8200 -3920 8200 -3760 {lab=GND}
N 10030 -3920 10030 -3760 {lab=GND}
N 9660 -3760 10030 -3760 {lab=GND}
N 9490 -4650 10030 -4650 {lab=VD2}
N 8200 -4650 8740 -4650 {lab=VD1}
N 8200 -3760 9040 -3760 {lab=GND}
N 9870 -5060 9940 -5060 {lab=GND}
N 9940 -5060 9940 -4970 {lab=GND}
N 9830 -4970 9940 -4970 {lab=GND}
N 9830 -5030 9830 -4880 {lab=GND}
N 9830 -5180 9830 -5090 {lab=Y}
N 9490 -5180 9830 -5180 {lab=Y}
N 9725 -5060 9830 -5060 {lab=GND}
N 9725 -5060 9725 -4970 {lab=GND}
N 9725 -4970 9830 -4970 {lab=GND}
N 8400 -5840 8530 -5840 {lab=VDD}
N 8530 -5930 8530 -5840 {lab=VDD}
N 8400 -5930 8530 -5930 {lab=VDD}
N 8400 -5930 8400 -5870 {lab=VDD}
N 8270 -5930 8270 -5840 {lab=VDD}
N 8270 -5930 8400 -5930 {lab=VDD}
N 8270 -5840 8360 -5840 {lab=VDD}
N 8400 -5990 8740 -5990 {lab=VDD}
N 8400 -5990 8400 -5930 {lab=VDD}
N 8400 -5810 8400 -5750 {lab=VD3}
N 8400 -5750 8740 -5750 {lab=VD3}
N 9700 -5420 9830 -5420 {lab=VD4}
N 9700 -5510 9700 -5420 {lab=VD4}
N 9700 -5510 9830 -5510 {lab=VD4}
N 9830 -5510 9830 -5450 {lab=VD4}
N 9960 -5510 9960 -5420 {lab=VD4}
N 9830 -5510 9960 -5510 {lab=VD4}
N 9870 -5420 9960 -5420 {lab=VD4}
N 9490 -5570 9830 -5570 {lab=VD4}
N 9830 -5570 9830 -5510 {lab=VD4}
N 9830 -5390 9830 -5330 {lab=Y}
N 9490 -5330 9830 -5330 {lab=Y}
N 8400 -5420 8530 -5420 {lab=VD3}
N 8530 -5510 8530 -5420 {lab=VD3}
N 8400 -5510 8530 -5510 {lab=VD3}
N 8400 -5510 8400 -5450 {lab=VD3}
N 8270 -5510 8270 -5420 {lab=VD3}
N 8270 -5510 8400 -5510 {lab=VD3}
N 8270 -5420 8360 -5420 {lab=VD3}
N 8400 -5570 8740 -5570 {lab=VD3}
N 8400 -5570 8400 -5510 {lab=VD3}
N 8400 -5390 8400 -5330 {lab=X}
N 8400 -5330 8740 -5330 {lab=X}
N 13730 -5270 13800 -5270 {lab=VDD}
N 13800 -5360 13800 -5270 {lab=VDD}
N 13690 -5360 13800 -5360 {lab=VDD}
N 13690 -5360 13690 -5300 {lab=VDD}
N 13580 -5360 13690 -5360 {lab=VDD}
N 13580 -5360 13580 -5270 {lab=VDD}
N 13580 -5270 13690 -5270 {lab=VDD}
N 13690 -5240 13690 -5200 {lab=V_err_p}
N 13380 -5200 13690 -5200 {lab=V_err_p}
N 13690 -5400 13690 -5360 {lab=VDD}
N 13380 -5400 13690 -5400 {lab=VDD}
N 12860 -4550 12930 -4550 {lab=VDD}
N 12860 -4640 12860 -4550 {lab=VDD}
N 12860 -4640 12970 -4640 {lab=VDD}
N 12970 -4640 12970 -4580 {lab=VDD}
N 12970 -4640 13080 -4640 {lab=VDD}
N 13080 -4640 13080 -4550 {lab=VDD}
N 12970 -4550 13080 -4550 {lab=VDD}
N 12970 -4520 12970 -4470 {lab=err_amp_out}
N 12970 -4680 12970 -4640 {lab=VDD}
N 11480 -5050 11550 -5050 {lab=VDD}
N 11480 -5140 11480 -5050 {lab=VDD}
N 11480 -5140 11590 -5140 {lab=VDD}
N 11590 -5140 11590 -5080 {lab=VDD}
N 11590 -5140 11700 -5140 {lab=VDD}
N 11700 -5140 11700 -5050 {lab=VDD}
N 11590 -5050 11700 -5050 {lab=VDD}
N 11590 -5180 11590 -5140 {lab=VDD}
N 11590 -4960 11960 -4960 {lab=V_err_gate}
N 11590 -5020 11590 -4960 {lab=V_err_gate}
N 12970 -4470 13260 -4470 {lab=err_amp_out}
N 13830 -4550 13900 -4550 {lab=VDD}
N 13900 -4640 13900 -4550 {lab=VDD}
N 13790 -4640 13900 -4640 {lab=VDD}
N 13790 -4640 13790 -4580 {lab=VDD}
N 13680 -4640 13790 -4640 {lab=VDD}
N 13680 -4640 13680 -4550 {lab=VDD}
N 13680 -4550 13790 -4550 {lab=VDD}
N 13790 -4520 13790 -4470 {lab=err_amp_mir}
N 13790 -4680 13790 -4640 {lab=VDD}
N 13500 -4470 13790 -4470 {lab=err_amp_mir}
N 15000 -6040 15090 -6040 {lab=VDD}
N 15130 -6040 15180 -6040 {lab=VDD}
N 14840 -6100 15090 -6100 {lab=VDD}
N 15090 -6100 15090 -6070 {lab=VDD}
N 15180 -6100 15180 -6040 {lab=VDD}
N 15090 -6100 15180 -6100 {lab=VDD}
N 15000 -6100 15000 -6040 {lab=VDD}
N 15090 -6010 15090 -5890 {lab=GND}
N 14760 -5890 15090 -5890 {lab=GND}
N 15970 -6040 16060 -6040 {lab=VDD}
N 15880 -6040 15930 -6040 {lab=VDD}
N 15970 -6100 16240 -6100 {lab=VDD}
N 15970 -6100 15970 -6070 {lab=VDD}
N 15880 -6100 15880 -6040 {lab=VDD}
N 15880 -6100 15970 -6100 {lab=VDD}
N 16060 -6100 16060 -6040 {lab=VDD}
N 15970 -6010 15970 -5890 {lab=GND}
N 15970 -5890 16320 -5890 {lab=GND}
N 15970 -5500 16060 -5500 {lab=GND}
N 15880 -5500 15930 -5500 {lab=GND}
N 15970 -5440 16240 -5440 {lab=GND}
N 15970 -5470 15970 -5440 {lab=GND}
N 15880 -5500 15880 -5440 {lab=GND}
N 15880 -5440 15970 -5440 {lab=GND}
N 16060 -5500 16060 -5440 {lab=GND}
N 15970 -5650 15970 -5530 {lab=VDD}
N 15970 -5650 16320 -5650 {lab=VDD}
N 15000 -5500 15090 -5500 {lab=GND}
N 15130 -5500 15180 -5500 {lab=GND}
N 14840 -5440 15090 -5440 {lab=GND}
N 15090 -5470 15090 -5440 {lab=GND}
N 15180 -5500 15180 -5440 {lab=GND}
N 15090 -5440 15180 -5440 {lab=GND}
N 15000 -5500 15000 -5440 {lab=GND}
N 15090 -5650 15090 -5530 {lab=VDD}
N 14760 -5650 15090 -5650 {lab=VDD}
N 20120 -4770 20190 -4770 {lab=GND}
N 20120 -4840 20120 -4770 {lab=GND}
N 20120 -4840 20190 -4840 {lab=GND}
N 20190 -4810 20190 -4700 {lab=GND}
N 19900 -4700 20190 -4700 {lab=GND}
N 18520 -5540 18590 -5540 {lab=VDD}
N 18590 -5610 18590 -5540 {lab=VDD}
N 18520 -5610 18590 -5610 {lab=VDD}
N 18520 -5610 18520 -5570 {lab=VDD}
N 18420 -5540 18480 -5540 {lab=VDD}
N 18420 -5610 18420 -5540 {lab=VDD}
N 18420 -5610 18520 -5610 {lab=VDD}
N 18520 -5650 18520 -5610 {lab=VDD}
N 18520 -5650 18830 -5650 {lab=VDD}
N 20230 -4840 20290 -4840 {lab=GND}
N 20290 -4840 20290 -4770 {lab=GND}
N 20190 -4770 20290 -4770 {lab=GND}
N 20190 -4910 20190 -4870 {lab=VOUT+}
N 19900 -4910 20190 -4910 {lab=VOUT+}
N 18540 -4770 18610 -4770 {lab=GND}
N 18610 -4840 18610 -4770 {lab=GND}
N 18540 -4840 18610 -4840 {lab=GND}
N 18540 -4810 18540 -4700 {lab=GND}
N 18540 -4700 18830 -4700 {lab=GND}
N 18440 -4840 18500 -4840 {lab=GND}
N 18440 -4840 18440 -4770 {lab=GND}
N 18440 -4770 18540 -4770 {lab=GND}
N 18540 -4910 18540 -4870 {lab=VOUT-}
N 18540 -4910 18830 -4910 {lab=VOUT-}
N 20140 -5540 20210 -5540 {lab=VDD}
N 20140 -5610 20140 -5540 {lab=VDD}
N 20140 -5610 20210 -5610 {lab=VDD}
N 20210 -5610 20210 -5570 {lab=VDD}
N 20210 -5510 20210 -5440 {lab=VOUT+}
N 19900 -5440 20210 -5440 {lab=VOUT+}
N 20250 -5540 20310 -5540 {lab=VDD}
N 20310 -5610 20310 -5540 {lab=VDD}
N 20210 -5610 20310 -5610 {lab=VDD}
N 20210 -5650 20210 -5610 {lab=VDD}
N 19900 -5650 20210 -5650 {lab=VDD}
N 8200 -3950 8320 -3950 {lab=GND}
N 8320 -3950 8320 -3860 {lab=GND}
N 8200 -3860 8320 -3860 {lab=GND}
N 9910 -3950 10030 -3950 {lab=GND}
N 9910 -3950 9910 -3860 {lab=GND}
N 9910 -3860 10030 -3860 {lab=GND}
N 18520 -5510 18520 -5440 {lab=VOUT-}
N 18520 -5440 18830 -5440 {lab=VOUT-}
N 2210 -6200 2210 -6120 {lab=VDD}
N 2210 -6120 2300 -6120 {lab=VDD}
N 2210 -6200 2260 -6200 {lab=VDD}
N 13690 -3960 13730 -3960 {lab=GND}
N 13690 -3960 13690 -3910 {lab=GND}
N 13690 -3910 13730 -3910 {lab=GND}
N 13730 -3930 13730 -3850 {lab=GND}
N 13500 -3850 13730 -3850 {lab=GND}
N 13770 -3960 13810 -3960 {lab=GND}
N 13810 -3960 13810 -3910 {lab=GND}
N 13730 -3910 13810 -3910 {lab=GND}
N 13730 -4040 13730 -3990 {lab=err_amp_mir}
N 13500 -4040 13730 -4040 {lab=err_amp_mir}
N 13030 -3960 13070 -3960 {lab=GND}
N 13070 -3960 13070 -3910 {lab=GND}
N 13030 -3910 13070 -3910 {lab=GND}
N 13030 -3930 13030 -3850 {lab=GND}
N 13030 -3850 13260 -3850 {lab=GND}
N 12950 -3960 12990 -3960 {lab=GND}
N 12950 -3960 12950 -3910 {lab=GND}
N 12950 -3910 13030 -3910 {lab=GND}
N 13030 -4040 13030 -3990 {lab=err_amp_out}
N 13030 -4040 13260 -4040 {lab=err_amp_out}
N 8290 -5060 8360 -5060 {lab=GND}
N 8290 -5060 8290 -4970 {lab=GND}
N 8290 -4970 8400 -4970 {lab=GND}
N 8400 -5030 8400 -4880 {lab=GND}
N 8400 -5180 8400 -5090 {lab=X}
N 8400 -5180 8740 -5180 {lab=X}
N 8400 -5060 8505 -5060 {lab=GND}
N 8505 -5060 8505 -4970 {lab=GND}
N 8400 -4970 8505 -4970 {lab=GND}
N 3490 -5960 3490 -5760 {lab=Vb3}
N 9700 -5840 9830 -5840 {lab=VDD}
N 9700 -5930 9700 -5840 {lab=VDD}
N 9700 -5930 9830 -5930 {lab=VDD}
N 9830 -5930 9830 -5870 {lab=VDD}
N 9960 -5930 9960 -5840 {lab=VDD}
N 9830 -5930 9960 -5930 {lab=VDD}
N 9870 -5840 9960 -5840 {lab=VDD}
N 9490 -5990 9830 -5990 {lab=VDD}
N 9830 -5990 9830 -5930 {lab=VDD}
N 9830 -5810 9830 -5750 {lab=VD4}
N 9490 -5750 9830 -5750 {lab=VD4}
N 8020 -1640 8020 -1580 {lab=VIN-}
N 8150 -1640 8150 -1580 {lab=VIN+}
N 18690 -5150 18690 -5110 {lab=VOUT-}
N 20050 -5150 20050 -5110 {lab=VOUT+}
C {devices/vsource.sym} 8020 -1800 0 0 {name=V1 value="pwl(0 0 1us 0 2us 1.8)" savecurrent=false
* 1.8}
C {devices/gnd.sym} 8020 -1770 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 8020 -1830 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 7740 -1850 0 0 {name=CORNER only_toplevel=false corner=tt}
C {simulator_commands_shown.sym} 8420 -2160 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
* ngspice commands


.option method=gear
.option wnflag=1
.option savecurrents
* .temp =140

.save
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm71.msky130_fd_pr__nfet_01v8[vth]
+@m.xm70.msky130_fd_pr__pfet_01v8[vth]
+@m.xm72.msky130_fd_pr__nfet_01v8[vth]
+@m.xm74.msky130_fd_pr__pfet_01v8[vth]
+@m.xm73.msky130_fd_pr__nfet_01v8[vth]
+@m.xm75.msky130_fd_pr__nfet_01v8[vth]
+@m.xm77.msky130_fd_pr__pfet_01v8[vth]
+@m.xm76.msky130_fd_pr__nfet_01v8[vth]
+@m.xm82.msky130_fd_pr__pfet_01v8[vth]
+@m.xm84.msky130_fd_pr__nfet_01v8[vth]
+@m.xm85.msky130_fd_pr__pfet_01v8[vth]

* .ic v(vin-) = 0.8
* .ic v(vin+) = 0.8
* .ic v(v_top) = 1.8

.control

    save all
    * dc temp -40 120 5 V1 1.6 2.0 0.05
    * dc V1 1.7 1.9 0.001 temp -40 120 40
    * dc V1 0.0 2.0 0.02 temp -40 120 20
    * dc V1 0 2.0 0.02
    * tran 0.4ns 5us
    tran 2ns 30us
    remzerovec
    write tb_bgr_opamp_dummy_param_check.raw
.endc

"}
C {sky130_fd_pr/pfet_01v8.sym} 9730 -9980 0 0 {name=M45
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9750 -9350 0 1 {name=R4
L=12.7
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10500 -9350 0 0 {name=R5
L=12
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 10480 -9840 0 0 {name=M50
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10500 -9560 0 1 {name=p41 sig_type=std_logic lab=V_CUR_REF_REG}
C {lab_wire.sym} 9580 -9980 2 0 {name=p56 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9480 -10080 2 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=20 spiceprefix=X}
C {devices/lab_pin.sym} 8930 -9270 2 0 {name=p67 sig_type=std_logic lab=Vbe2}
C {sky130_fd_pr/pnp_05v5.sym} 8530 -9200 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 8910 -9200 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8570 -10060 0 1 {name=M51
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8910 -10060 0 0 {name=M53
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8830 -9530 2 0 {name=p70 sig_type=std_logic lab=bgr_Vin+}
C {lab_wire.sym} 8640 -9530 2 1 {name=p71 sig_type=std_logic lab=bgr_Vin-}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8930 -9350 0 0 {name=R3
L=2.3
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9190 -9350 0 1 {name=R6
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8310 -9350 0 0 {name=R7
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 7560 -9760 0 1 {name=M54
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7560 -10060 0 1 {name=M55
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7540 -9950 2 1 {name=p72 sig_type=std_logic lab=START_UP}
C {lab_wire.sym} 7790 -10060 0 0 {name=p73 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/pfet_01v8.sym} 7770 -9950 0 0 {name=M56
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7560 -9410 0 1 {name=M57
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 7540 -9650 2 0 {name=p90 sig_type=std_logic lab=START_UP_NFET1}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 8730 -9720 1 1 {name=x1}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 10240 -9840 2 1 {name=x2}
C {sky130_fd_pr/pfet_01v8.sym} 11190 -9840 0 0 {name=M70
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11230 -9270 0 1 {name=M71
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11910 -9270 0 0 {name=M72
W=1
L=0.15
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12510 -9270 0 0 {name=M73
W=1
L=0.15
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11910 -9840 0 0 {name=M74
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13130 -9270 0 0 {name=M75
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13550 -9270 0 0 {name=M76
W=1
L=0.15
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13130 -9840 0 0 {name=M77
W=1
L=0.15
nf=1
mult=8
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10890 -9740 2 0 {name=p95 sig_type=std_logic lab=PFET_GATE_10uA}
C {lab_wire.sym} 11780 -9350 0 0 {name=p96 sig_type=std_logic lab=NFET_GATE_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 11430 -9840 0 1 {name=M78
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11010 -9270 0 0 {name=M79
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10720 -9840 0 1 {name=M80
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12730 -9270 0 1 {name=M81
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13550 -9840 0 0 {name=M82
W=1
L=0.15
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9960 -9980 0 0 {name=M83
W=6
L=0.5
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14120 -9270 0 0 {name=M84
W=1
L=0.15
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14120 -9840 0 0 {name=M85
W=1
L=0.15
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13770 -9270 0 1 {name=M86
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14340 -9270 0 1 {name=M87
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12130 -9270 0 1 {name=M88
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13790 -9840 0 1 {name=M89
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14360 -9840 0 1 {name=M90
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12150 -9840 0 1 {name=M91
W=1
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8020 -9950 0 1 {name=M92
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 11930 -9620 2 1 {name=p109 sig_type=std_logic lab=Vb1}
C {devices/lab_pin.sym} 11930 -9470 2 1 {name=p64 sig_type=std_logic lab=Vb2}
C {devices/lab_pin.sym} 12530 -9470 2 1 {name=p97 sig_type=std_logic lab=Vb3}
C {devices/lab_pin.sym} 13150 -9620 2 1 {name=p98 sig_type=std_logic lab=V_tail_gate}
C {devices/lab_pin.sym} 13150 -9470 2 1 {name=p99 sig_type=std_logic lab=V_err_gate}
C {devices/lab_pin.sym} 13570 -9470 2 1 {name=p102 sig_type=std_logic lab=V_CMFB_S2}
C {devices/lab_pin.sym} 13570 -9620 2 1 {name=p101 sig_type=std_logic lab=V_CMFB_S1}
C {devices/lab_pin.sym} 14140 -9470 2 1 {name=p103 sig_type=std_logic lab=V_CMFB_S4}
C {devices/lab_pin.sym} 14140 -9620 2 1 {name=p104 sig_type=std_logic lab=V_CMFB_S3}
C {devices/lab_pin.sym} 14600 -10000 2 0 {name=p107 sig_type=std_logic lab=V_err_amp_ref}
C {devices/gnd.sym} 8650 -9720 0 1 {name=l1 lab=GND}
C {devices/vdd.sym} 8810 -9720 0 0 {name=l2 lab=VDD}
C {devices/gnd.sym} 8250 -9350 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 8740 -9050 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 8870 -9350 0 1 {name=l7 lab=GND}
C {devices/gnd.sym} 9250 -9350 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 9810 -9350 0 0 {name=l9 lab=GND}
C {devices/vdd.sym} 8740 -10240 0 0 {name=l10 lab=VDD}
C {devices/gnd.sym} 10440 -9350 0 1 {name=l11 lab=GND}
C {devices/gnd.sym} 10240 -9900 2 1 {name=l12 lab=GND}
C {devices/vdd.sym} 10240 -9780 2 0 {name=l13 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 8720 -4450 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9510 -4450 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8760 -5060 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9470 -5060 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8760 -5420 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9470 -5420 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8760 -5840 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9470 -5840 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8910 -5840 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 8910 -5420 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 9020 -4190 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6950 -4190 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6750 -4450 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7120 -4450 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9020 -4600 0 0 {name=M19
W=1
L=2.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8740 -5250 0 0 {name=p16 sig_type=std_logic lab=X}
C {lab_pin.sym} 9490 -5250 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 14740 -5600 0 0 {name=M25
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14740 -5940 0 0 {name=M26
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 14520 -5780 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 16570 -5780 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 15400 -5990 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 15400 -5550 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 15660 -5990 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 15660 -5550 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_wire.sym} 15530 -5780 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 16340 -5600 0 1 {name=M27
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 16340 -5940 0 1 {name=M28
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13520 -4880 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13240 -4880 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13480 -3960 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13280 -3960 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 13620 -4880 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 13360 -5270 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11940 -5050 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12220 -5050 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 12330 -5050 0 1 {name=p34 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 11830 -5050 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 12100 -5270 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 18850 -4840 0 1 {name=M37
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 19880 -4840 0 0 {name=M38
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 18850 -5540 0 1 {name=M39
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19880 -5540 0 0 {name=M40
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 19200 -5540 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 19530 -5540 0 0 {name=p46 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 18990 -4960 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 19740 -4960 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 9360 -4190 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 9040 -4330 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 8740 -4710 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 9490 -4710 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 8910 -4600 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 8470 -4190 0 0 {name=p21 sig_type=std_logic lab=V_tail_gate}
C {lab_wire.sym} 6930 -4330 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 8740 -5650 0 1 {name=p23 sig_type=std_logic lab=VD3}
C {lab_pin.sym} 9490 -5650 0 0 {name=p57 sig_type=std_logic lab=VD4}
C {lab_pin.sym} 13500 -4210 0 1 {name=p33 sig_type=std_logic lab=err_amp_mir}
C {lab_wire.sym} 13340 -4980 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 12120 -5150 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 12720 -5270 0 1 {name=p39 sig_type=std_logic lab=V_err_gate}
C {lab_wire.sym} 13050 -4190 0 0 {name=p40 sig_type=std_logic lab=err_amp_out}
C {lab_wire.sym} 19370 -4840 2 0 {name=p43 sig_type=std_logic lab=V_b_2nd_stage}
C {lab_wire.sym} 8910 -5060 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/pfet_01v8.sym} 2730 -6010 0 1 {name=M5
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3510 -5990 0 1 {name=M6
W=3.6
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3510 -6210 0 1 {name=M43
W=3.2
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3610 -6210 0 1 {name=p6 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 2830 -6010 0 1 {name=p7 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3690 -5990 0 1 {name=p8 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3490 -6130 0 0 {name=p12 sig_type=std_logic lab=Vb2_Vb3}
C {lab_wire.sym} 7130 -4720 0 1 {name=p75 sig_type=std_logic lab=V_tail_gate}
C {sky130_fd_pr/cap_mim_m3_1.sym} 19730 -5310 1 1 {name=C6 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 19000 -5310 3 0 {name=C7 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/pfet_01v8.sym} 2280 -6200 0 0 {name=M1
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2440 -5940 0 0 {name=M2
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3950 -6210 0 1 {name=M3
W=1.6
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3950 -5990 0 1 {name=M4
W=1.2
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7120 -4050 0 1 {name=M21
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9560 -4090 0 1 {name=M22
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -4450 0 0 {name=M23
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8180 -3950 0 0 {name=M24
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 10050 -3950 0 1 {name=M46
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9850 -5060 0 1 {name=M47
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8380 -5840 0 0 {name=M48
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9850 -5420 0 1 {name=M49
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8380 -5420 0 0 {name=M52
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13710 -5270 0 1 {name=M58
W=1.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12950 -4550 0 0 {name=M59
W=0.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11570 -5050 0 0 {name=M60
W=1.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13810 -4550 0 1 {name=M61
W=0.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 15110 -6040 0 1 {name=M62
W=4
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 15950 -6040 0 0 {name=M63
W=4
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 15950 -5500 0 0 {name=M64
W=6
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 15110 -5500 0 1 {name=M65
W=6
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 20210 -4840 0 1 {name=M66
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 18500 -5540 0 0 {name=M68
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 18520 -4840 0 0 {name=M69
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 20230 -5540 0 1 {name=M67
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 19150 -5310 0 1 {name=p11 sig_type=std_logic lab=cap_res_X}
C {lab_pin.sym} 19580 -5310 0 0 {name=p28 sig_type=std_logic lab=cap_res_Y}
C {sky130_fd_pr/res_high_po_1p41.sym} 19150 -5430 0 1 {name=R1
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_1p41.sym} 19580 -5430 0 0 {name=R2
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 13750 -3960 0 1 {name=M20
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13010 -3960 0 0 {name=M42
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8380 -5060 0 0 {name=M44
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 12080 -4720 2 1 {name=p111 sig_type=std_logic lab=V_err_gate}
C {lab_pin.sym} 13130 -4880 0 0 {name=p2 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 6930 -4990 0 0 {name=p100 sig_type=std_logic lab=V_tail_gate}
C {lab_pin.sym} 9040 -5630 0 0 {name=p106 sig_type=std_logic lab=Vb1}
C {lab_pin.sym} 2710 -5760 0 0 {name=p60 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3490 -5760 0 0 {name=p61 sig_type=std_logic lab=Vb3}
C {devices/lab_pin.sym} 14640 -5550 2 1 {name=p3 sig_type=std_logic lab=V_CMFB_S2}
C {devices/lab_pin.sym} 16440 -5550 2 0 {name=p108 sig_type=std_logic lab=V_CMFB_S4}
C {devices/lab_pin.sym} 14640 -5990 2 1 {name=p114 sig_type=std_logic lab=V_CMFB_S1}
C {devices/lab_pin.sym} 16430 -5990 2 0 {name=p115 sig_type=std_logic lab=V_CMFB_S3}
C {sky130_fd_pr/pfet_01v8.sym} 9850 -5840 0 1 {name=M93
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 14710 -5890 2 0 {name=r15 node=v(@m.xm26.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 14710 -5650 0 1 {name=r8 node=v(@m.xm25.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 16370 -5890 2 1 {name=r9 node=v(@m.xm28.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 16370 -5650 0 0 {name=r14 node=v(@m.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vsource.sym} 8020 -1550 0 1 {name=V2 value="sin(1.24 -0.001 100k)" savecurrent=false
* "1.24 AC -1"
* "sin(1.24 -0.001 1Meg)"
* "sin(0.2 -0.001 1Meg)" 
* "pulse(1.24 1.04 0ns 2ns 2ns 48ns 100ns)"
* "pulse(1.24 1.23 0ns 2ns 2ns 48ns 100ns)" "pulse(1.24 1.23 0ns 0.8ns 0.8ns 19.2ns 40ns)"}
C {devices/gnd.sym} 8020 -1520 0 1 {name=l14 lab=GND}
C {devices/vsource.sym} 8150 -1550 0 0 {name=V3 value="sin(1.24 0.001 100k)" savecurrent=false
* "1.24 AC 1"
* "sin(1.24 0.001 1Meg)"  
* "sin(0.2 0.001 1Meg)" "pulse(1.24 1.44 0ns 2ns 2ns 48ns 100ns)"
* 1.24
*  "pulse(1.24 1.34 0ns 2ns 2ns 48ns 100ns)" "pulse(1.24 1.25 0ns 0.8ns 0.8ns 19.2ns 40ns)"}
C {devices/gnd.sym} 8150 -1520 0 0 {name=l15 lab=GND}
C {lab_wire.sym} 8020 -1640 0 0 {name=p58 sig_type=std_logic lab=VIN-}
C {lab_wire.sym} 8150 -1640 0 1 {name=p62 sig_type=std_logic lab=VIN+}
C {lab_wire.sym} 8570 -4320 2 1 {name=p74 sig_type=std_logic lab=VIN-}
C {lab_wire.sym} 9620 -4320 2 0 {name=p82 sig_type=std_logic lab=VIN+}
C {lab_pin.sym} 18590 -5150 0 0 {name=p4 sig_type=std_logic lab=VOUT-}
C {lab_pin.sym} 20150 -5150 0 1 {name=p5 sig_type=std_logic lab=VOUT+}
C {devices/gnd.sym} 14760 -5410 0 0 {name=l16 lab=GND}
C {devices/vdd.sym} 3070 -6450 0 1 {name=l17 lab=VDD}
C {devices/vdd.sym} 14760 -5680 0 1 {name=l18 lab=VDD}
C {devices/vdd.sym} 8920 -6050 0 1 {name=l19 lab=VDD}
C {devices/gnd.sym} 6930 -3950 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} 9040 -3670 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} 9830 -4880 0 0 {name=l22 lab=GND}
C {devices/gnd.sym} 8400 -4880 0 1 {name=l23 lab=GND}
C {devices/vdd.sym} 12080 -5550 0 1 {name=l24 lab=VDD}
C {devices/vdd.sym} 13380 -5550 0 1 {name=l25 lab=VDD}
C {devices/vdd.sym} 11590 -5180 0 1 {name=l26 lab=VDD}
C {devices/vdd.sym} 13790 -4680 0 1 {name=l27 lab=VDD}
C {devices/vdd.sym} 12970 -4680 0 1 {name=l28 lab=VDD}
C {devices/gnd.sym} 13380 -3800 0 0 {name=l29 lab=GND}
C {devices/gnd.sym} 15400 -5530 0 1 {name=l30 lab=GND}
C {devices/gnd.sym} 16320 -5410 0 1 {name=l31 lab=GND}
C {devices/vdd.sym} 16320 -5680 0 0 {name=l32 lab=VDD}
C {devices/gnd.sym} 15660 -5530 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 14760 -5860 0 0 {name=l34 lab=GND}
C {devices/vdd.sym} 14760 -6150 0 1 {name=l35 lab=VDD}
C {devices/gnd.sym} 15400 -6010 2 0 {name=l36 lab=GND}
C {devices/gnd.sym} 16320 -5860 0 1 {name=l37 lab=GND}
C {devices/vdd.sym} 16320 -6150 0 0 {name=l38 lab=VDD}
C {devices/gnd.sym} 15660 -6010 2 1 {name=l39 lab=GND}
C {devices/vdd.sym} 18830 -5690 0 0 {name=l42 lab=VDD}
C {devices/vdd.sym} 19900 -5690 0 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 19170 -5430 3 1 {name=l44 lab=GND}
C {devices/gnd.sym} 19560 -5430 1 0 {name=l45 lab=GND}
C {devices/gnd.sym} 18990 -4940 0 0 {name=l46 lab=GND}
C {devices/gnd.sym} 19740 -4940 0 1 {name=l47 lab=GND}
C {devices/gnd.sym} 18830 -4640 0 0 {name=l48 lab=GND}
C {devices/gnd.sym} 19900 -4640 0 1 {name=l49 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 18690 -5080 0 0 {name=C2 model=cap_mim_m3_1 W=23 L=23 MF=1 spiceprefix=X}
C {devices/gnd.sym} 18690 -5050 0 1 {name=l50 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 20050 -5080 0 1 {name=C3 model=cap_mim_m3_1 W=23 L=23 MF=1 spiceprefix=X}
C {devices/gnd.sym} 20050 -5050 0 0 {name=l51 lab=GND}
C {devices/ngspice_get_value.sym} 13510 -9800 2 0 {name=r16 node=v(@m.xm82.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 13510 -9420 2 0 {name=r17 node=v(@m.xm76.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 14100 -9800 2 0 {name=r18 node=v(@m.xm85.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 14100 -9420 2 0 {name=r19 node=v(@m.xm84.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 13090 -9800 2 0 {name=r20 node=v(@m.xm77.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 13090 -9420 2 0 {name=r21 node=v(@m.xm75.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 11880 -9800 2 0 {name=r24 node=v(@m.xm74.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 11880 -9420 2 0 {name=r25 node=v(@m.xm72.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 11180 -9800 2 0 {name=r26 node=v(@m.xm70.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 11180 -9420 2 0 {name=r27 node=v(@m.xm71.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 12490 -9420 2 0 {name=r28 node=v(@m.xm73.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
