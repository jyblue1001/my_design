v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1770 -1480 2380 -930 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-7.7e-15


color="7 6"
node="vin+
vin-"}
B 2 930 -1480 1090 -1360 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-2.2e-186


color=6
node=v_out}
B 2 250 -1230 480 -1050 {flags=graph

y2=1.9739002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.18609979



node="vdd
vin-
vin+"
color="7 6 4"}
B 2 250 -810 480 -670 {flags=graph

y2=1.1e-09
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=4e-25



color=6
node=i(@m.xm4.msky130_fd_pr__pfet_01v8[id])}
B 2 1770 -890 2380 -340 {flags=graph

y2=0.01
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0



color=7
node=v_out}
B 2 250 -1020 480 -840 {flags=graph

y2=0.9998693
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.039869305




color="7 6 12"
node="start_up
v_top
v_out"}
B 2 1770 -2080 2380 -1530 {flags=graph

y2=0.85
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.83




color=7
node=v_top}
B 2 2540 -890 3150 -340 {flags=graph

y2=0.01
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=3
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0



color=7
node=x}
N 730 -630 1110 -630 {
lab=GND}
N 690 -710 690 -630 {
lab=GND}
N 1070 -710 1070 -630 {
lab=GND}
N 690 -630 730 -630 {
lab=GND}
N 770 -1320 910 -1320 {
lab=V_TOP}
N 910 -1320 1070 -1320 {
lab=V_TOP}
N 730 -1510 730 -1350 {
lab=VDD}
N 730 -1510 1110 -1510 {
lab=VDD}
N 1110 -1510 1110 -1350 {
lab=VDD}
N 1110 -1510 1520 -1510 {
lab=VDD}
N 570 -1000 730 -1000 {
lab=Vin-}
N 1110 -790 1110 -740 {lab=Vbe2}
N 1300 -790 1300 -630 {lab=GND}
N 570 -790 570 -630 {lab=GND}
N 1110 -1000 1300 -1000 {lab=Vin+}
N 1110 -630 1300 -630 {lab=GND}
N 1520 -870 1520 -630 {lab=GND}
N 1300 -630 1520 -630 {lab=GND}
N 1110 -1320 1150 -1320 {lab=VDD}
N 1150 -1390 1150 -1320 {lab=VDD}
N 690 -1320 730 -1320 {lab=VDD}
N 690 -1390 690 -1320 {lab=VDD}
N 1520 -1510 1520 -1350 {
lab=VDD}
N 1520 -1320 1560 -1320 {lab=VDD}
N 1560 -1390 1560 -1320 {lab=VDD}
N 1520 -1390 1560 -1390 {lab=VDD}
N 1050 -1320 1050 -1270 {lab=V_TOP}
N 1050 -1270 1460 -1270 {lab=V_TOP}
N 1460 -1320 1460 -1270 {lab=V_TOP}
N 1460 -1320 1480 -1320 {lab=V_TOP}
N 1520 -1130 1620 -1130 {lab=V_OUT}
N 930 -1070 1110 -1070 {lab=Vin+}
N 730 -1070 890 -1070 {lab=Vin-}
N 570 -630 690 -630 {lab=GND}
N 1110 -680 1110 -630 {lab=GND}
N 730 -680 730 -630 {lab=GND}
N 1110 -890 1110 -850 {lab=#net1}
N 730 -900 730 -740 {lab=#net2}
N 1520 -1000 1520 -930 {lab=#net3}
N 1520 -1290 1520 -1060 {lab=V_OUT}
N 1110 -1290 1110 -1240 {lab=#net4}
N 730 -1290 730 -1240 {lab=#net5}
N 520 -1320 520 -1280 {lab=V_TOP}
N 180 -1220 180 -1130 {lab=start_up}
N 180 -1510 180 -1350 {
lab=VDD}
N 140 -1320 180 -1320 {lab=VDD}
N 140 -1390 140 -1320 {lab=VDD}
N 140 -1390 180 -1390 {lab=VDD}
N 180 -1290 180 -1220 {lab=start_up}
N 180 -1510 730 -1510 {lab=VDD}
N 520 -1320 610 -1320 {lab=V_TOP}
N 610 -1320 610 -1270 {lab=V_TOP}
N 610 -1270 850 -1270 {lab=V_TOP}
N 180 -1250 480 -1250 {lab=start_up}
N 180 -630 570 -630 {lab=GND}
N 910 -1320 910 -1200 {lab=V_TOP}
N 730 -1180 730 -960 {lab=Vin-}
N 1110 -1180 1110 -950 {lab=Vin+}
N 850 -1320 850 -1270 {lab=V_TOP}
N 520 -1100 730 -1100 {lab=Vin-}
N 140 -1030 180 -1030 {lab=GND}
N 140 -1100 140 -1030 {lab=GND}
N 140 -1100 180 -1100 {lab=GND}
N 180 -1070 180 -1000 {lab=GND}
N 180 -710 180 -630 {lab=GND}
N 520 -1250 560 -1250 {lab=VDD}
N 520 -1120 520 -1100 {lab=Vin-}
N 520 -1220 520 -1180 {lab=#net6}
N 180 -1000 180 -710 {lab=GND}
N 1300 -900 1300 -850 {lab=#net7}
N 1300 -1000 1300 -960 {lab=Vin+}
N 570 -1000 570 -960 {lab=Vin-}
N 570 -900 570 -850 {lab=#net8}
N 220 -1320 520 -1320 {lab=V_TOP}
N 180 -1160 240 -1160 {lab=start_up}
N 240 -1160 240 -1100 {lab=start_up}
N 220 -1100 240 -1100 {lab=start_up}
N 690 -1390 730 -1390 {lab=VDD}
N 1110 -1390 1150 -1390 {lab=VDD}
N 7500 -950 7500 -860 {lab=#net9}
N 7500 -860 8250 -860 {lab=#net9}
N 8250 -950 8250 -860 {lab=#net9}
N 7500 -1560 7500 -1010 {lab=#net10}
N 8250 -1560 8250 -1010 {lab=#net11}
N 7540 -1590 8210 -1590 {lab=#net12}
N 7500 -1920 7500 -1620 {lab=X}
N 8250 -1920 8250 -1620 {lab=Y}
N 7500 -2340 7500 -1980 {lab=#net13}
N 8250 -2340 8250 -1980 {lab=#net14}
N 7540 -1950 8210 -1950 {lab=Vb2}
N 8250 -1950 8320 -1950 {lab=#net14}
N 8320 -2020 8320 -1950 {lab=#net14}
N 8250 -2020 8320 -2020 {lab=#net14}
N 7430 -1950 7500 -1950 {lab=#net13}
N 7430 -2020 7430 -1950 {lab=#net13}
N 7430 -2020 7500 -2020 {lab=#net13}
N 7500 -2520 7500 -2400 {lab=VDD}
N 8250 -2520 8250 -2400 {lab=VDD}
N 7540 -2370 8210 -2370 {lab=Vb3}
N 8250 -2370 8320 -2370 {lab=VDD}
N 8320 -2440 8320 -2370 {lab=VDD}
N 8250 -2440 8320 -2440 {lab=VDD}
N 7430 -2370 7500 -2370 {lab=VDD}
N 7430 -2440 7430 -2370 {lab=VDD}
N 7430 -2440 7500 -2440 {lab=VDD}
N 7500 -2520 8250 -2520 {lab=VDD}
N 7450 -1590 7500 -1590 {lab=GND}
N 7450 -1590 7450 -1530 {lab=GND}
N 7450 -1530 8310 -1530 {lab=GND}
N 8310 -1590 8310 -1530 {lab=GND}
N 8250 -1590 8310 -1590 {lab=GND}
N 7680 -2580 7680 -2520 {lab=VDD}
N 7950 -980 8250 -980 {lab=GND}
N 7500 -980 7950 -980 {lab=GND}
N 7800 -860 7800 -750 {lab=#net9}
N 7950 -980 7950 -720 {lab=GND}
N 7800 -720 7950 -720 {lab=GND}
N 7800 -690 7800 -600 {lab=GND}
N 7800 -640 7950 -640 {lab=GND}
N 7950 -720 7950 -640 {lab=GND}
N 8290 -980 8380 -980 {lab=opamp_Vin+}
N 6500 -860 6500 -750 {lab=#net15}
N 6420 -720 6500 -720 {lab=GND}
N 6500 -690 6500 -600 {lab=GND}
N 6420 -640 6500 -640 {lab=GND}
N 6420 -720 6420 -640 {lab=GND}
N 6540 -720 7760 -720 {lab=#net16}
N 6500 -1910 6500 -1850 {lab=VDD}
N 6580 -980 6670 -980 {lab=GND}
N 6340 -980 6580 -980 {lab=GND}
N 6340 -950 6340 -860 {lab=#net15}
N 6340 -860 6670 -860 {lab=#net15}
N 6670 -950 6670 -860 {lab=#net15}
N 6420 -980 6420 -720 {lab=GND}
N 6340 -1130 6340 -1010 {lab=#net16}
N 6340 -1130 6670 -1130 {lab=#net16}
N 6670 -1130 6670 -1010 {lab=#net16}
N 6710 -980 6780 -980 {lab=opamp_Vin+}
N 6230 -980 6300 -980 {lab=opamp_Vin-}
N 6500 -1250 7150 -1250 {lab=#net16}
N 7150 -1250 7150 -720 {lab=#net16}
N 7800 -1240 7800 -1160 {lab=#net17}
N 7800 -1270 7950 -1270 {lab=GND}
N 7800 -1130 7950 -1130 {lab=GND}
N 7800 -1100 7800 -860 {lab=#net9}
N 7800 -1590 7800 -1300 {lab=#net12}
N 7670 -1130 7760 -1130 {lab=#net12}
N 7670 -1390 7670 -1130 {lab=#net12}
N 7670 -1390 7800 -1390 {lab=#net12}
N 7670 -1270 7760 -1270 {lab=#net12}
N 7800 -2160 7800 -1590 {lab=#net12}
N 7800 -2520 7800 -2220 {lab=VDD}
N 3360 -920 3360 -800 {lab=Vb2}
N 4140 -920 4140 -800 {lab=Vb3}
N 3360 -1130 3360 -980 {lab=#net18}
N 4140 -1130 4140 -980 {lab=#net19}
N 4070 -950 4140 -950 {lab=#net19}
N 4070 -1020 4070 -950 {lab=#net19}
N 4070 -1020 4140 -1020 {lab=#net19}
N 3290 -950 3360 -950 {lab=#net18}
N 3290 -1020 3290 -950 {lab=#net18}
N 3290 -1020 3360 -1020 {lab=#net18}
N 3360 -1310 3360 -1190 {lab=VDD}
N 4140 -1310 4140 -1190 {lab=VDD}
N 4070 -1160 4140 -1160 {lab=VDD}
N 4070 -1230 4070 -1160 {lab=VDD}
N 4070 -1230 4140 -1230 {lab=VDD}
N 3290 -1160 3360 -1160 {lab=VDD}
N 3290 -1230 3290 -1160 {lab=VDD}
N 3290 -1230 3360 -1230 {lab=VDD}
N 3560 -1370 3560 -1310 {lab=VDD}
N 3360 -1310 4140 -1310 {lab=VDD}
N 3400 -1160 3480 -1160 {lab=Vb2}
N 3400 -950 3480 -950 {lab=Vb2}
N 4180 -1160 4260 -1160 {lab=Vb3}
N 4260 -1160 4260 -850 {lab=Vb3}
N 4140 -850 4260 -850 {lab=Vb3}
N 3480 -1160 3480 -850 {lab=Vb2}
N 3360 -850 3480 -850 {lab=Vb2}
N 4180 -950 4340 -950 {lab=Vb2}
N 11280 -1410 11280 -1360 {lab=VDD}
N 11280 -1200 11280 -1140 {lab=GND}
N 11280 -1300 11280 -1260 {lab=#net20}
N 11280 -1640 11280 -1590 {lab=GND}
N 11280 -1750 11280 -1700 {lab=#net21}
N 11160 -1670 11160 -1330 {lab=X}
N 11910 -1670 11980 -1670 {lab=Y}
N 11980 -1670 11980 -1330 {lab=Y}
N 11910 -1330 11980 -1330 {lab=Y}
N 11040 -1510 11160 -1510 {lab=X}
N 11980 -1510 12100 -1510 {lab=Y}
N 11720 -1720 11870 -1720 {lab=#net22}
N 11720 -1280 11870 -1280 {lab=#net23}
N 11280 -1670 11360 -1670 {lab=VDD}
N 11280 -1830 11360 -1830 {lab=VDD}
N 11280 -1860 11280 -1800 {lab=VDD}
N 11360 -1830 11360 -1670 {lab=VDD}
N 11280 -1170 11360 -1170 {lab=GND}
N 11280 -1330 11360 -1330 {lab=GND}
N 11360 -1330 11360 -1170 {lab=GND}
N 11870 -1410 11870 -1360 {lab=VDD}
N 11870 -1200 11870 -1140 {lab=GND}
N 11870 -1300 11870 -1260 {lab=#net23}
N 11870 -1640 11870 -1590 {lab=GND}
N 11870 -1750 11870 -1700 {lab=#net22}
N 11790 -1670 11870 -1670 {lab=VDD}
N 11790 -1830 11870 -1830 {lab=VDD}
N 11870 -1860 11870 -1800 {lab=VDD}
N 11790 -1830 11790 -1670 {lab=VDD}
N 11790 -1170 11870 -1170 {lab=GND}
N 11790 -1330 11870 -1330 {lab=GND}
N 11790 -1330 11790 -1170 {lab=GND}
N 11580 -1720 11580 -1280 {lab=V_tot}
N 10250 -910 10250 -840 {lab=#net24}
N 10010 -910 10250 -910 {lab=#net24}
N 10010 -910 10010 -840 {lab=#net24}
N 10130 -960 10130 -910 {lab=#net24}
N 10130 -1070 10130 -1020 {lab=VDD}
N 10250 -780 10250 -660 {lab=#net25}
N 10010 -780 10010 -660 {lab=#net26}
N 10250 -600 10250 -550 {lab=GND}
N 10010 -550 10250 -550 {lab=GND}
N 10010 -600 10010 -550 {lab=GND}
N 10130 -550 10130 -500 {lab=GND}
N 10010 -810 10250 -810 {lab=VDD}
N 10050 -630 10210 -630 {lab=#net25}
N 9970 -630 10010 -630 {lab=GND}
N 9970 -630 9970 -580 {lab=GND}
N 9970 -580 10010 -580 {lab=GND}
N 10250 -630 10290 -630 {lab=GND}
N 10290 -630 10290 -580 {lab=GND}
N 10250 -580 10290 -580 {lab=GND}
N 10150 -710 10250 -710 {lab=#net25}
N 10150 -710 10150 -630 {lab=#net25}
N 11580 -1280 11580 -810 {lab=V_tot}
N 9880 -810 9970 -810 {lab=V_ref}
N 7950 -720 8100 -720 {lab=GND}
N 7950 -640 8100 -640 {lab=GND}
N 8100 -690 8100 -640 {lab=GND}
N 8100 -860 8100 -750 {lab=#net9}
N 10290 -810 11580 -810 {lab=V_tot}
N 12120 -1270 12120 -1210 {lab=V_ref}
N 10130 -990 10170 -990 {lab=VDD}
N 10170 -1050 10170 -990 {lab=VDD}
N 10130 -1050 10170 -1050 {lab=VDD}
N 10170 -990 10170 -810 {lab=VDD}
N 9170 -910 9170 -840 {lab=#net27}
N 9170 -910 9410 -910 {lab=#net27}
N 9410 -910 9410 -840 {lab=#net27}
N 9290 -960 9290 -910 {lab=#net27}
N 9290 -1070 9290 -1020 {lab=VDD}
N 9170 -810 9410 -810 {lab=VDD}
N 9450 -810 9540 -810 {lab=V_ref}
N 9250 -990 9290 -990 {lab=VDD}
N 9250 -1050 9250 -990 {lab=VDD}
N 9250 -1050 9290 -1050 {lab=VDD}
N 9250 -990 9250 -810 {lab=VDD}
N 9330 -990 10090 -990 {lab=#net28}
N 9170 -780 9170 -720 {lab=#net28}
N 9170 -720 9410 -720 {lab=#net28}
N 9410 -780 9410 -720 {lab=#net28}
N 9290 -720 9290 -600 {lab=#net28}
N 9040 -810 9130 -810 {lab=V_tot}
N 9290 -540 9290 -490 {lab=GND}
N 9730 -990 9730 -660 {lab=#net28}
N 9290 -660 9730 -660 {lab=#net28}
N 8140 -720 8840 -720 {lab=#net26}
N 8840 -720 8840 -360 {lab=#net26}
N 8840 -360 9860 -360 {lab=#net26}
N 9860 -730 9860 -360 {lab=#net26}
N 9860 -730 10010 -730 {lab=#net26}
N 7950 -1270 7950 -980 {lab=GND}
N 7950 -1530 7950 -1270 {lab=GND}
N 4900 -1190 4900 -890 {lab=V_OUT_X}
N 5660 -1190 5660 -890 {lab=V_OUT_Y}
N 5660 -1220 5730 -1220 {lab=VDD}
N 5730 -1290 5730 -1220 {lab=VDD}
N 5660 -1290 5730 -1290 {lab=VDD}
N 4830 -1220 4900 -1220 {lab=VDD}
N 4830 -1290 4900 -1290 {lab=VDD}
N 4830 -1290 4830 -1220 {lab=VDD}
N 4900 -1320 4900 -1250 {lab=VDD}
N 5660 -1320 5660 -1250 {lab=VDD}
N 4900 -830 4900 -660 {lab=GND}
N 5660 -830 5660 -660 {lab=GND}
N 5660 -790 5730 -790 {lab=GND}
N 5730 -860 5730 -790 {lab=GND}
N 5660 -860 5730 -860 {lab=GND}
N 4830 -790 4900 -790 {lab=GND}
N 4830 -860 4900 -860 {lab=GND}
N 4830 -860 4830 -790 {lab=GND}
N 4940 -1220 5050 -1220 {lab=X}
N 5510 -1220 5620 -1220 {lab=Y}
N 4790 -1050 4900 -1050 {lab=V_OUT_X}
N 5660 -1050 5770 -1050 {lab=V_OUT_Y}
N 4900 -1320 5660 -1320 {lab=VDD}
N 4900 -660 5660 -660 {lab=GND}
N 5280 -1380 5280 -1320 {lab=VDD}
N 5280 -660 5280 -600 {lab=GND}
N 5280 -860 5280 -790 {lab=#net29}
N 5280 -730 5280 -660 {lab=GND}
N 5530 -980 5660 -980 {lab=V_OUT_Y}
N 5280 -860 5620 -860 {lab=#net29}
N 5340 -980 5470 -980 {lab=#net29}
N 5340 -980 5340 -860 {lab=#net29}
N 4900 -980 5030 -980 {lab=V_OUT_X}
N 5090 -980 5220 -980 {lab=#net29}
N 4940 -860 5280 -860 {lab=#net29}
N 5220 -980 5220 -860 {lab=#net29}
N 11490 -1280 11660 -1280 {lab=V_tot}
N 11490 -1720 11660 -1720 {lab=V_tot}
N 11280 -1720 11430 -1720 {lab=#net21}
N 11280 -1280 11430 -1280 {lab=#net20}
N 11160 -1670 11240 -1670 {lab=X}
N 11160 -1330 11240 -1330 {lab=X}
N 7330 -980 7460 -980 {lab=opamp_Vin-}
N 8380 -980 8380 -940 {lab=opamp_Vin+}
N 7330 -980 7330 -940 {lab=opamp_Vin-}
N 560 -1510 560 -1250 {lab=VDD}
N 8380 -940 8380 -850 {lab=opamp_Vin+}
N 7330 -940 7330 -850 {lab=opamp_Vin-}
N 6500 -1790 6500 -1660 {lab=#net30}
N 6500 -1730 6600 -1730 {lab=#net30}
N 6600 -1730 6600 -1630 {lab=#net30}
N 6540 -1630 6600 -1630 {lab=#net30}
N 6500 -1520 6600 -1520 {lab=#net31}
N 6600 -1520 6600 -1420 {lab=#net31}
N 6540 -1420 6600 -1420 {lab=#net31}
N 6500 -1390 6500 -1130 {lab=#net16}
N 6500 -1600 6500 -1450 {lab=#net31}
N 6420 -1420 6420 -980 {lab=GND}
N 6420 -1420 6500 -1420 {lab=GND}
N 6420 -1630 6500 -1630 {lab=GND}
N 6420 -1630 6420 -1420 {lab=GND}
C {devices/gnd.sym} 630 -380 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 630 -440 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 190 -460 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/code.sym} 400 -460 0 0 {name=CODE only_toplevel=false value="

.option method=trap
.option wnflag=1
.option savecurrents
* .temp =140

.save
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[gm]

* .ic v(vin-) = 0.8
.ic v(v_top) = 1.8

.control
  save all
  * dc temp -40 120 10 VDD 0 2.0 0.1
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  tran 1ns 10us
  remzerovec
  write tb_low_voltage_BGR_2.raw
  set appendwrite
.endc


"}
C {devices/gnd.sym} 910 -630 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 970 -1130 1 0 {name=l5 lab=VDD}
C {devices/gnd.sym} 850 -1130 1 0 {name=l8 lab=GND
W=4}
C {devices/lab_pin.sym} 1110 -760 2 0 {name=p5 sig_type=std_logic lab=Vbe2}
C {devices/vdd.sym} 910 -1510 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} 1620 -1130 2 0 {name=p4 sig_type=std_logic lab=V_OUT
}
C {sky130_fd_pr/pnp_05v5.sym} 710 -710 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1090 -710 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {devices/gnd.sym} 1090 -820 1 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1280 -820 1 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1500 -900 1 0 {name=l9 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 750 -1320 0 1 {name=M1
W=43
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1090 -1320 0 0 {name=M2
W=43
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1500 -1320 0 0 {name=M3
W=43
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 550 -820 1 0 {name=l10 lab=GND}
C {lab_wire.sym} 1260 -1270 2 0 {name=p2 sig_type=std_logic lab=V_TOP}
C {lab_wire.sym} 1010 -1070 2 0 {name=p6 sig_type=std_logic lab=Vin+}
C {lab_wire.sym} 820 -1070 2 1 {name=p1 sig_type=std_logic lab=Vin-}
C {ammeter.sym} 730 -930 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {ammeter.sym} 1110 -920 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {ammeter.sym} 1520 -1030 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1110 -820 0 0 {name=R1
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1300 -820 0 0 {name=R2
L=28.9
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 570 -820 0 0 {name=R3
L=28.9
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1520 -900 0 0 {name=R4
L=33.6
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {ammeter.sym} 730 -1210 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0
L=1}
C {ammeter.sym} 1110 -1210 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 200 -1100 0 1 {name=M5
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 200 -1320 0 1 {name=M6
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 180 -1250 2 1 {name=p7 sig_type=std_logic lab=start_up}
C {lab_wire.sym} 520 -1100 2 1 {name=p3 sig_type=std_logic lab=Vin-}
C {lab_wire.sym} 520 -1320 0 0 {name=p8 sig_type=std_logic lab=V_TOP}
C {ammeter.sym} 520 -1150 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0
L=1}
C {sky130_fd_pr/pfet_01v8.sym} 500 -1250 0 0 {name=M4
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ammeter.sym} 570 -930 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {ammeter.sym} 1300 -930 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {/foss/designs/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 910 -1130 1 1 {name=x1}
C {sky130_fd_pr/nfet_01v8.sym} 7480 -980 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8270 -980 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7520 -1590 0 1 {name=M9
W=32
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8230 -1590 0 0 {name=M10
W=32
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7520 -1950 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8230 -1950 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7520 -2370 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8230 -2370 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 7680 -2580 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 7670 -2370 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 7670 -1950 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 7780 -720 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 7800 -600 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 7330 -790 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 6520 -720 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 6500 -600 0 0 {name=l14 lab=GND}
C {isource.sym} 6500 -1820 0 0 {name=I0 value=100u}
C {vdd.sym} 6500 -1910 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 6320 -980 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6690 -980 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7780 -1130 0 0 {name=M19
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7780 -1270 0 0 {name=M20
W=1
L=2.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 7800 -2190 0 0 {name=I1 value=10u}
C {lab_pin.sym} 7500 -1780 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 3380 -950 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4160 -950 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3380 -1160 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4160 -1160 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3560 -1370 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 4260 -1160 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 3480 -950 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 4340 -950 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {isource.sym} 3360 -770 0 0 {name=I2 value=50u}
C {gnd.sym} 3360 -740 0 1 {name=l17 lab=GND}
C {isource.sym} 4140 -770 0 0 {name=I3 value=50u}
C {gnd.sym} 4140 -740 0 1 {name=l18 lab=GND}
C {lab_pin.sym} 8250 -1780 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 11260 -1330 0 0 {name=M25
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11260 -1670 0 0 {name=M26
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 11280 -1230 0 0 {name=I4 value=20u}
C {vdd.sym} 11280 -1410 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 11280 -1140 0 0 {name=l20 lab=GND}
C {isource.sym} 11280 -1770 0 0 {name=I5 value=20u}
C {vdd.sym} 11280 -1860 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 11280 -1590 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 11040 -1510 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 12100 -1510 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11460 -1720 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 11460 -1740 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11460 -1280 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 11460 -1260 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11690 -1720 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 11690 -1740 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11690 -1280 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 11690 -1260 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 11580 -1510 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 11890 -1330 0 1 {name=M27
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11890 -1670 0 1 {name=M28
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 11870 -1230 0 1 {name=I6 value=20u}
C {vdd.sym} 11870 -1410 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 11870 -1140 0 1 {name=l28 lab=GND}
C {isource.sym} 11870 -1770 0 1 {name=I7 value=20u}
C {vdd.sym} 11870 -1860 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 11870 -1590 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 10270 -810 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9990 -810 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 9290 -570 0 0 {name=I8 value=20u}
C {vdd.sym} 10130 -1070 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 10230 -630 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 10030 -630 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 10130 -500 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 9880 -810 0 0 {name=p28 sig_type=std_logic lab=V_ref}
C {devices/vsource.sym} 12120 -1180 0 1 {name=VDD1 value=0.9 savecurrent=false
}
C {devices/gnd.sym} 12120 -1150 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 12120 -1270 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 10370 -810 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 10110 -990 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -810 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9430 -810 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 9290 -1070 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 9540 -810 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 9040 -810 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 9310 -990 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9290 -490 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 8380 -790 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 7330 -820 0 1 {name=V2 value="sin(1.24 -0.001 1Meg)" savecurrent=false
* 1.24
* }
C {lab_wire.sym} 6230 -980 0 0 {name=p41 sig_type=std_logic lab=opamp_Vin-}
C {lab_wire.sym} 6780 -980 0 1 {name=p42 sig_type=std_logic lab=opamp_Vin+}
C {devices/vsource.sym} 8380 -820 0 0 {name=V1 value="sin(1.24 0.001 1Meg)" savecurrent=false
* "1.24 AC 1"
* 1.24
* 0.001 }
C {sky130_fd_pr/nfet_01v8.sym} 4920 -860 0 1 {name=M37
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5640 -860 0 0 {name=M38
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4920 -1220 0 1 {name=M39
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5640 -1220 0 0 {name=M40
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 5050 -1220 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 5510 -1220 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 4790 -1050 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 5770 -1050 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 5280 -1380 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 5280 -600 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 5060 -980 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 5060 -960 0 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 5500 -980 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 5500 -960 0 1 {name=l40 lab=GND}
C {isource.sym} 5280 -760 0 0 {name=I9 value=2u}
C {sky130_fd_pr/nfet_01v8.sym} 8120 -720 0 1 {name=M41
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8380 -870 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 7330 -870 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {devices/vsource.sym} 630 -410 0 0 {name=VDD2 value="pwl(0 0 1us 0 2us 1.8)" savecurrent=false
* 1.8}
C {sky130_fd_pr/nfet_01v8.sym} 6520 -1630 0 1 {name=M43
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6520 -1420 0 1 {name=M42
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
