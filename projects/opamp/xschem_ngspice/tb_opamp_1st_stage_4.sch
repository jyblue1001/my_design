v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 3710 -1010 3880 -920 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm14.msky130_fd_pr__nfet_01v8[vth] @m.xm13.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 3330 -860 3500 -770 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vs14 v_p - \\""}
B 2 3140 -860 3310 -770 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p -\\""}
B 2 3520 -860 3690 -770 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p @m.xm13.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 3330 -1010 3500 -920 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vs14 - \\""}
B 2 3140 -1010 3310 -920 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs14 -\\""}
B 2 3520 -1010 3690 -920 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs14 @m.xm14.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 760 -1870 930 -1750 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 -\\""}
B 2 740 -2090 910 -2000 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v1 vb2 @m.xm15.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 390 -2090 560 -2000 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm17.msky130_fd_pr__pfet_01v8[vth] @m.xm15.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 390 -2300 560 -2210 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v1 -\\""}
B 2 650 -2230 820 -2140 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 @m.xm17.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 1550 -2090 1720 -1970 {flags=graph
y1=1
y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 -\\""}
B 2 1130 -2080 1300 -1990 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm18.msky130_fd_pr__pfet_01v8[vth] @m.xm16.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 1130 -2250 1300 -2160 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v2 -\\""}
B 2 1550 -2240 1720 -2150 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 @m.xm18.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 380 -1860 550 -1770 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v1 vb2 - \\""}
B 2 1550 -1850 1720 -1760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 @m.xm16.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 1160 -1850 1330 -1760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb3 - \\""}
B 2 1990 -2020 2160 -1900 {flags=graph
y1=0.43
y2=0.45
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vd7 -\\""}
B 2 1810 -1730 1980 -1610 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 x -\\""}
B 2 2000 -1530 2170 -1410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd x -\\""}
B 2 2000 -1730 2170 -1610 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 vb2 @m.xm5.msky130_fd_pr__pfet_01v8[vth] + -\\""}
B 2 3170 -1520 3340 -1400 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd y -\\""}
B 2 2940 -380 3140 -290 {flags=graph
y1=0.72
y2=0.73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"err_opamp_out @m.xm27.msky130_fd_pr__nfet_01v8[vth] - \\""}
B 2 2320 -380 2540 -290 {flags=graph
y1=0.72
y2=0.73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vgs9 @m.xm9.msky130_fd_pr__nfet_01v8[vth] - \\""}
B 2 1360 -400 1530 -310 {flags=graph
y1=0.72
y2=0.73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vgs9 @m.xm10.msky130_fd_pr__nfet_01v8[vth] - \\""}
B 2 2080 -840 2250 -750 {flags=graph
y1=0.72
y2=0.73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vin- v_p @m.xm1.msky130_fd_pr__nfet_01v8[vth] + - \\""}
B 2 2120 -1180 2290 -1060 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vd1 @m.xm3.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 5070 -790 5240 -670 {flags=graph
y1=0.91
y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd y -\\""}
B 2 3790 -2660 4800 -1930 {flags=graph
y1=3.3e-09
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color="7 6"
node="x
y"
autoload=0}
B 2 3790 -1870 4800 -1140 {flags=graph
y1=-8.1e-10
y2=4.9e-09
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"x y - \\""}
B 2 3790 -3460 4800 -2730 {flags=graph
y1=-180
y2=180
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0
linewidth_mult=5



color=7
node=ph(x)}
B 2 3140 -1180 3310 -1080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vd2 @m.xm4.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 3170 -1730 3340 -1610 {flags=graph
y1=0.16
y2=0.57
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd6 vb2 @m.xm6.msky130_fd_pr__pfet_01v8[vth] + -\\""}
B 2 3510 -2390 3680 -2270 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vd6 -\\""}
B 2 3510 -2250 3680 -2130 {flags=graph
y1=0.69
y2=0.83
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd6 y -\\""}
B 2 3510 -2110 3680 -1990 {flags=graph
y1=0.198
y2=0.328
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"y vd2 -\\""}
B 2 3510 -1970 3680 -1850 {flags=graph
y1=0.19
y2=0.22
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd2 v_p -\\""}
B 2 3510 -1830 3680 -1710 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=v_p}
B 2 3390 -1520 3560 -1400 {flags=graph
y1=0.72
y2=1.2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=y}
B 2 3390 -1380 3560 -1260 {flags=graph
y1=0.72
y2=1.2
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=x}
B 2 3310 -2110 3480 -1990 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=y}
B 2 3310 -2250 3480 -2130 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v_tot y -\\""}
B 2 1790 -970 2060 -760 {flags=graph
y1=-0.15
y2=-0.065
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=1
linewidth_mult=1


color="7 6"
node="x
y"
autoload=0}
B 2 3790 -4260 4800 -3530 {flags=graph
y1=0.021
y2=40
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0
linewidth_mult=5




color=6
node=x}
B 2 1990 -2180 2160 -2060 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 @m.xm7.msky130_fd_pr__pfet_01v8[vth] + -\\""
rainbow=1}
B 2 2800 -880 2970 -790 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p @m.xm13.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 2800 -1030 2970 -940 {flags=graph
y1=0.876
y2=0.896
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vs14 v_p - \\""}
B 2 2590 -3450 2760 -3330 {flags=graph
y1=0.9
y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd y -\\""}
B 2 1990 -3590 2160 -3470 {flags=graph
y1=0.36
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd v_out_x -\\""}
B 2 2210 -4430 3220 -3700 {flags=graph
y1=-1.7
y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=5




color=6
node="\\"v_out_x v_out_y -\\""}
B 2 1070 -4430 2080 -3700 {flags=graph
y1=0.072
y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=2




color=6
node=v_out_x}
B 2 2210 -6000 3220 -5270 {flags=graph
y1=-2.2
y2=2.5
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=3e-06
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=1
linewidth_mult=5







color=6
node=v_out_x}
B 2 2210 -5220 3220 -4490 {flags=graph
y1=-360
y2=1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0
linewidth_mult=5







color=6
node="\\"ph(v_out_x) 180 -\\""}
B 2 1990 -3430 2160 -3310 {flags=graph
y1=0.25
y2=0.28
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd x @m.xm34.msky130_fd_pr__pfet_01v8[vth] + -\\""
rainbow=1}
B 2 2080 -980 2250 -890 {flags=graph
y1=0.72
y2=0.73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vd1 v_p - \\""}
B 2 1920 -1180 2090 -1060 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"x vd1 -\\""}
B 2 1990 -3130 2160 -3010 {flags=graph
y1=0.36
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=v_out_x}
B 2 1990 -2970 2160 -2850 {flags=graph
y1=0.25081554
y2=0.25215772
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v_b @m.xm32.msky130_fd_pr__nfet_01v8[vth] -\\""
rainbow=1}
B 2 1720 -1180 1890 -1060 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vd1 -\\""}
B 2 6530 -2960 7130 -2550 {flags=graph
y1=0.89000745
y2=0.89044726
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=v_tot}
B 2 6800 -1470 7330 -1240 {flags=graph
y1=0.8912971
y2=0.89144121
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=v_tot}
B 2 6890 -1180 7110 -1020 {flags=graph
y1=0.35
y2=0.68
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color="6 7"
node="\\"v_1 y -\\"
\\"y v_2 -\\""}
B 2 7150 -1180 7370 -1020 {flags=graph
y1=0.17
y2=0.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"v_1 y v_2 + -\\""}
B 2 1990 -2770 2160 -2650 {flags=graph
y1=0.25081554
y2=0.25215772
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node=\\"v_b\\"
rainbow=1}
B 2 820 -3550 1830 -2820 {flags=graph
y1=0.86390653
y2=0.86445628
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=5





color=7
node=v_b}
B 2 2890 590 3160 800 {flags=graph
y1=0.99
y2=1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1




autoload=0

color=6
node=bgr_v_top}
B 2 2890 830 3160 1040 {flags=graph
y1=0.047
y2=0.048
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1




autoload=0
color=6
node=bgr_v_out}
T {VTH14-VTH13} 3740 -910 0 0 0.3 0.3 {}
T {VDS13} 3390 -760 0 0 0.3 0.3 {}
T {VGS13} 3200 -760 0 0 0.3 0.3 {}
T {Vin_CM=V_p+VGS1
   =220mV+850mV
   =1070mV

   =187mV+883mV
   =1070mV} 1850 -740 0 0 0.3 0.3 {}
T {Vb1=V_p+VDS1+VGS3
   =220mV+220mV+850mV
   =1290mV

   =220mV+220mV+923mV
   =1363mV

} 1970 -1360 0 0 0.3 0.3 {}
T {Vb2=VDD-VDS7+VGS5
   =1800V-440mV-1050mV
   =310mV} 1940 -1820 0 0 0.3 0.3 {}
T {Vb3=VDD-VGS7
   =1800V-1050mV
   =750mV} 1940 -2300 0 0 0.3 0.3 {}
T {VGS13-VTH13} 3550 -760 0 0 0.3 0.3 {}
T {VDS14} 3390 -910 0 0 0.3 0.3 {}
T {VGS14} 3200 -910 0 0 0.3 0.3 {}
T {VGS14-VTH14} 3550 -910 0 0 0.3 0.3 {}
T {VDS17} 340 -2270 0 0 0.3 0.3 {}
T {VGS17-VTH17} 830 -2200 0 0 0.3 0.3 {}
T {VTH17-VTH15} 280 -2050 0 0 0.3 0.3 {}
T {VGS15-VTH15} 780 -1990 0 0 0.3 0.3 {}
T {VDS15} 330 -1830 0 0 0.3 0.3 {}
T {VDS18} 1070 -2210 0 0 0.3 0.3 {}
T {VGS18-VTH18} 1740 -2210 0 0 0.3 0.3 {}
T {VTH18-VTH16} 1010 -2040 0 0 0.3 0.3 {}
T {VGS16-VTH16} 1730 -1810 0 0 0.3 0.3 {}
T {VDS16} 1220 -1750 0 0 0.3 0.3 {}
T {Vb2} 830 -1740 0 0 0.3 0.3 {}
T {Vb3} 1730 -2040 0 0 0.3 0.3 {}
T {VDS5} 1870 -1600 0 0 0.3 0.3 {}
T {VGS5} 2060 -1400 0 0 0.3 0.3 {}
T {VGS5-VTH5} 2040 -1600 0 0 0.3 0.3 {}
T {VGS27-VTH27} 2970 -280 0 0 0.3 0.3 {}
T {VGS3-VTH3} 2160 -1050 0 0 0.3 0.3 {}
T {VGS1-VTH1} 2130 -740 0 0 0.3 0.3 {}
T {VGS4-VTH4} 3180 -1070 0 0 0.3 0.3 {}
T {VGS6-VTH6} 3210 -1600 0 0 0.3 0.3 {}
T {VGS7-VTH7} 2030 -2050 0 0 0.3 0.3 {}
T {VGS13-VTH13} 2830 -780 0 0 0.3 0.3 {}
T {VDS13} 2860 -930 0 0 0.3 0.3 {}
T {VGS34-VTH34} 2030 -3300 0 0 0.3 0.3 {}
T {VDS34} 2050 -3460 0 0 0.3 0.3 {}
T {VDS1} 2150 -880 0 0 0.3 0.3 {}
T {VDS3} 1980 -1050 0 0 0.3 0.3 {}
T {VDS7} 2050 -1890 0 0 0.3 0.3 {}
T {VGS32-VTH32} 2020 -2840 0 0 0.3 0.3 {}
T {VDS32} 2050 -3000 0 0 0.3 0.3 {}
T {VGS3} 1790 -1050 0 0 0.3 0.3 {}
N 2300 -650 2300 -560 {lab=V_p}
N 2300 -560 3050 -560 {lab=V_p}
N 3050 -650 3050 -560 {lab=V_p}
N 2300 -1260 2300 -710 {lab=VD1}
N 3050 -1260 3050 -710 {lab=VD2}
N 2340 -1290 3010 -1290 {lab=Vb1}
N 2300 -1620 2300 -1320 {lab=X}
N 3050 -1620 3050 -1320 {lab=Y}
N 2300 -2040 2300 -1680 {lab=VD7}
N 3050 -2040 3050 -1680 {lab=VD6}
N 2340 -1650 3010 -1650 {lab=Vb2}
N 3050 -1650 3120 -1650 {lab=VD6}
N 3120 -1720 3120 -1650 {lab=VD6}
N 3050 -1720 3120 -1720 {lab=VD6}
N 2230 -1650 2300 -1650 {lab=VD7}
N 2230 -1720 2230 -1650 {lab=VD7}
N 2230 -1720 2300 -1720 {lab=VD7}
N 2300 -2220 2300 -2100 {lab=VDD}
N 3050 -2220 3050 -2100 {lab=VDD}
N 2340 -2070 3010 -2070 {lab=Vb3}
N 3050 -2070 3120 -2070 {lab=VDD}
N 3120 -2140 3120 -2070 {lab=VDD}
N 3050 -2140 3120 -2140 {lab=VDD}
N 2230 -2070 2300 -2070 {lab=VDD}
N 2230 -2140 2230 -2070 {lab=VDD}
N 2230 -2140 2300 -2140 {lab=VDD}
N 2300 -2220 3050 -2220 {lab=VDD}
N 2250 -1290 2300 -1290 {lab=GND}
N 2250 -1290 2250 -1230 {lab=GND}
N 2250 -1230 3110 -1230 {lab=GND}
N 3110 -1290 3110 -1230 {lab=GND}
N 3050 -1290 3110 -1290 {lab=GND}
N 2480 -2280 2480 -2220 {lab=VDD}
N 2750 -680 3050 -680 {lab=GND}
N 2300 -680 2750 -680 {lab=GND}
N 2600 -560 2600 -450 {lab=V_p}
N 2750 -680 2750 -420 {lab=GND}
N 2600 -420 2750 -420 {lab=GND}
N 2600 -390 2600 -300 {lab=GND}
N 2600 -340 2750 -340 {lab=GND}
N 2750 -420 2750 -340 {lab=GND}
N 3090 -680 3180 -680 {lab=V1_CM}
N 1300 -560 1300 -450 {lab=V_p_mir}
N 1220 -420 1300 -420 {lab=GND}
N 1300 -390 1300 -300 {lab=GND}
N 1220 -340 1300 -340 {lab=GND}
N 1220 -420 1220 -340 {lab=GND}
N 1340 -420 2560 -420 {lab=VGS9}
N 1300 -1150 1300 -1090 {lab=VDD}
N 1380 -680 1470 -680 {lab=GND}
N 1140 -680 1380 -680 {lab=GND}
N 1140 -650 1140 -560 {lab=V_p_mir}
N 1140 -560 1470 -560 {lab=V_p_mir}
N 1470 -650 1470 -560 {lab=V_p_mir}
N 1220 -680 1220 -420 {lab=GND}
N 1140 -830 1140 -710 {lab=VGS9}
N 1140 -830 1470 -830 {lab=VGS9}
N 1470 -830 1470 -710 {lab=VGS9}
N 1300 -1030 1300 -830 {lab=VGS9}
N 1510 -680 1580 -680 {lab=Vin+}
N 1030 -680 1100 -680 {lab=Vin-}
N 1300 -950 1700 -950 {lab=VGS9}
N 1700 -950 1700 -420 {lab=VGS9}
N 2600 -940 2600 -860 {lab=VS14}
N 2600 -970 2750 -970 {lab=GND}
N 2600 -830 2750 -830 {lab=GND}
N 2600 -800 2600 -560 {lab=V_p}
N 2600 -1290 2600 -1000 {lab=Vb1}
N 2470 -830 2560 -830 {lab=Vb1}
N 2470 -1090 2470 -830 {lab=Vb1}
N 2470 -1090 2600 -1090 {lab=Vb1}
N 2470 -970 2560 -970 {lab=Vb1}
N 2600 -1860 2600 -1290 {lab=Vb1}
N 2600 -2220 2600 -1920 {lab=VDD}
N 610 -1880 610 -1760 {lab=Vb2}
N 1390 -1880 1390 -1760 {lab=Vb3}
N 610 -2090 610 -1940 {lab=V1}
N 1390 -2090 1390 -1940 {lab=V2}
N 1320 -1910 1390 -1910 {lab=V2}
N 1320 -1980 1320 -1910 {lab=V2}
N 1320 -1980 1390 -1980 {lab=V2}
N 540 -1910 610 -1910 {lab=V1}
N 540 -1980 540 -1910 {lab=V1}
N 540 -1980 610 -1980 {lab=V1}
N 610 -2270 610 -2150 {lab=VDD}
N 1390 -2270 1390 -2150 {lab=VDD}
N 1320 -2120 1390 -2120 {lab=VDD}
N 1320 -2190 1320 -2120 {lab=VDD}
N 1320 -2190 1390 -2190 {lab=VDD}
N 540 -2120 610 -2120 {lab=VDD}
N 540 -2190 540 -2120 {lab=VDD}
N 540 -2190 610 -2190 {lab=VDD}
N 810 -2330 810 -2270 {lab=VDD}
N 610 -2270 1390 -2270 {lab=VDD}
N 650 -2120 730 -2120 {lab=Vb2}
N 650 -1910 730 -1910 {lab=Vb2}
N 1430 -2120 1510 -2120 {lab=Vb3}
N 1510 -2120 1510 -1810 {lab=Vb3}
N 1390 -1810 1510 -1810 {lab=Vb3}
N 730 -2120 730 -1810 {lab=Vb2}
N 610 -1810 730 -1810 {lab=Vb2}
N 1430 -1910 1590 -1910 {lab=Vb2}
N 6080 -1110 6080 -1060 {lab=VDD}
N 6080 -900 6080 -840 {lab=GND}
N 6080 -1000 6080 -960 {lab=#net1}
N 6080 -1340 6080 -1290 {lab=GND}
N 6080 -1450 6080 -1400 {lab=#net2}
N 5960 -1370 5960 -1030 {lab=X}
N 6710 -1370 6780 -1370 {lab=Y}
N 6780 -1370 6780 -1030 {lab=Y}
N 6710 -1030 6780 -1030 {lab=Y}
N 5840 -1210 5960 -1210 {lab=X}
N 6780 -1210 6900 -1210 {lab=Y}
N 6520 -1420 6670 -1420 {lab=V_1}
N 6520 -980 6670 -980 {lab=V_2}
N 6080 -1370 6160 -1370 {lab=VDD}
N 6080 -1530 6160 -1530 {lab=VDD}
N 6080 -1560 6080 -1500 {lab=VDD}
N 6160 -1530 6160 -1370 {lab=VDD}
N 6080 -870 6160 -870 {lab=GND}
N 6080 -1030 6160 -1030 {lab=GND}
N 6160 -1030 6160 -870 {lab=GND}
N 6670 -1110 6670 -1060 {lab=VDD}
N 6670 -900 6670 -840 {lab=GND}
N 6670 -1000 6670 -960 {lab=V_2}
N 6670 -1340 6670 -1290 {lab=GND}
N 6670 -1450 6670 -1400 {lab=V_1}
N 6590 -1370 6670 -1370 {lab=VDD}
N 6590 -1530 6670 -1530 {lab=VDD}
N 6670 -1560 6670 -1500 {lab=VDD}
N 6590 -1530 6590 -1370 {lab=VDD}
N 6590 -870 6670 -870 {lab=GND}
N 6590 -1030 6670 -1030 {lab=GND}
N 6590 -1030 6590 -870 {lab=GND}
N 6380 -1420 6380 -980 {lab=V_tot}
N 5050 -610 5050 -540 {lab=V_err_p}
N 4810 -610 5050 -610 {lab=V_err_p}
N 4810 -610 4810 -540 {lab=V_err_p}
N 4930 -660 4930 -610 {lab=V_err_p}
N 4930 -770 4930 -720 {lab=VDD}
N 5050 -480 5050 -360 {lab=err_opamp_mir}
N 4810 -480 4810 -360 {lab=err_opamp_out}
N 5050 -300 5050 -250 {lab=GND}
N 4810 -250 5050 -250 {lab=GND}
N 4810 -300 4810 -250 {lab=GND}
N 4930 -250 4930 -200 {lab=GND}
N 4810 -510 5050 -510 {lab=VDD}
N 4850 -330 5010 -330 {lab=err_opamp_mir}
N 4770 -330 4810 -330 {lab=GND}
N 4770 -330 4770 -280 {lab=GND}
N 4770 -280 4810 -280 {lab=GND}
N 5050 -330 5090 -330 {lab=GND}
N 5090 -330 5090 -280 {lab=GND}
N 5050 -280 5090 -280 {lab=GND}
N 4950 -410 5050 -410 {lab=err_opamp_mir}
N 4950 -410 4950 -330 {lab=err_opamp_mir}
N 6380 -980 6380 -510 {lab=V_tot}
N 4680 -510 4770 -510 {lab=V_ref}
N 2750 -420 2900 -420 {lab=GND}
N 2750 -340 2900 -340 {lab=GND}
N 2900 -390 2900 -340 {lab=GND}
N 2900 -560 2900 -450 {lab=V_p}
N 5090 -510 6380 -510 {lab=V_tot}
N 6920 -970 6920 -910 {lab=V_ref}
N 4930 -690 4970 -690 {lab=VDD}
N 4970 -750 4970 -690 {lab=VDD}
N 4930 -750 4970 -750 {lab=VDD}
N 4970 -690 4970 -510 {lab=VDD}
N 3970 -610 3970 -540 {lab=V_err_mir_p}
N 3970 -610 4210 -610 {lab=V_err_mir_p}
N 4210 -610 4210 -540 {lab=V_err_mir_p}
N 4090 -660 4090 -610 {lab=V_err_mir_p}
N 4090 -770 4090 -720 {lab=VDD}
N 3970 -510 4210 -510 {lab=VDD}
N 4250 -510 4340 -510 {lab=V_ref}
N 4050 -690 4090 -690 {lab=VDD}
N 4050 -750 4050 -690 {lab=VDD}
N 4050 -750 4090 -750 {lab=VDD}
N 4050 -690 4050 -510 {lab=VDD}
N 4130 -690 4890 -690 {lab=V_gate}
N 3970 -480 3970 -420 {lab=V_gate}
N 3970 -420 4210 -420 {lab=V_gate}
N 4210 -480 4210 -420 {lab=V_gate}
N 4090 -420 4090 -300 {lab=V_gate}
N 3840 -510 3930 -510 {lab=V_tot}
N 4090 -240 4090 -190 {lab=GND}
N 4530 -690 4530 -360 {lab=V_gate}
N 4090 -360 4530 -360 {lab=V_gate}
N 2940 -420 3640 -420 {lab=err_opamp_out}
N 3640 -420 3640 -60 {lab=err_opamp_out}
N 3640 -60 4660 -60 {lab=err_opamp_out}
N 4660 -430 4660 -60 {lab=err_opamp_out}
N 4660 -430 4810 -430 {lab=err_opamp_out}
N 2750 -970 2750 -680 {lab=GND}
N 2750 -1230 2750 -970 {lab=GND}
N 2310 -3360 2310 -3060 {lab=V_OUT_X}
N 3070 -3360 3070 -3060 {lab=V_OUT_Y}
N 3070 -3390 3140 -3390 {lab=VDD}
N 3140 -3460 3140 -3390 {lab=VDD}
N 3070 -3460 3140 -3460 {lab=VDD}
N 2240 -3390 2310 -3390 {lab=VDD}
N 2240 -3460 2310 -3460 {lab=VDD}
N 2240 -3460 2240 -3390 {lab=VDD}
N 2310 -3490 2310 -3420 {lab=VDD}
N 3070 -3490 3070 -3420 {lab=VDD}
N 2310 -3000 2310 -2830 {lab=GND}
N 3070 -3000 3070 -2830 {lab=GND}
N 3070 -2960 3140 -2960 {lab=GND}
N 3140 -3030 3140 -2960 {lab=GND}
N 3070 -3030 3140 -3030 {lab=GND}
N 2240 -2960 2310 -2960 {lab=GND}
N 2240 -3030 2310 -3030 {lab=GND}
N 2240 -3030 2240 -2960 {lab=GND}
N 2350 -3390 2460 -3390 {lab=X}
N 2920 -3390 3030 -3390 {lab=Y}
N 2200 -3220 2310 -3220 {lab=V_OUT_X}
N 3070 -3220 3180 -3220 {lab=V_OUT_Y}
N 2310 -3490 3070 -3490 {lab=VDD}
N 2310 -2830 3070 -2830 {lab=GND}
N 2690 -3550 2690 -3490 {lab=VDD}
N 2690 -2830 2690 -2770 {lab=GND}
N 2690 -3030 2690 -2960 {lab=V_b}
N 2690 -2900 2690 -2830 {lab=GND}
N 2940 -3150 3070 -3150 {lab=V_OUT_Y}
N 2690 -3030 3030 -3030 {lab=V_b}
N 2750 -3150 2880 -3150 {lab=V_b}
N 2750 -3150 2750 -3030 {lab=V_b}
N 2310 -3150 2440 -3150 {lab=V_OUT_X}
N 2500 -3150 2630 -3150 {lab=V_b}
N 2350 -3030 2690 -3030 {lab=V_b}
N 2630 -3150 2630 -3030 {lab=V_b}
N 2690 -3240 2690 -3180 {lab=VDD}
N 2690 -3120 2690 -3030 {lab=V_b}
N 6290 -980 6460 -980 {lab=V_tot}
N 6290 -1420 6460 -1420 {lab=V_tot}
N 6080 -1420 6230 -1420 {lab=#net2}
N 6080 -980 6230 -980 {lab=#net1}
N 5960 -1370 6040 -1370 {lab=X}
N 5960 -1030 6040 -1030 {lab=X}
N 6670 -980 6790 -980 {lab=V_2}
N 6670 -1420 6760 -1420 {lab=V_1}
N 2020 1150 2400 1150 {
lab=GND}
N 1980 1070 1980 1150 {
lab=GND}
N 2360 1070 2360 1150 {
lab=GND}
N 1980 1150 2020 1150 {
lab=GND}
N 2060 460 2200 460 {
lab=BGR_V_TOP}
N 2200 460 2360 460 {
lab=BGR_V_TOP}
N 2020 350 2020 430 {
lab=VDD}
N 2400 350 2400 430 {
lab=VDD}
N 1860 780 2020 780 {
lab=BGR_Vin-}
N 2400 990 2400 1040 {lab=BGR_Vbe2}
N 2700 990 2700 1150 {lab=GND}
N 1860 990 1860 1150 {lab=GND}
N 2400 780 2700 780 {lab=BGR_Vin+}
N 2400 1150 2700 1150 {lab=GND}
N 3320 910 3320 1150 {lab=GND}
N 2400 460 2440 460 {lab=VDD}
N 2440 390 2440 460 {lab=VDD}
N 2400 390 2440 390 {lab=VDD}
N 1980 460 2020 460 {lab=VDD}
N 1980 390 1980 460 {lab=VDD}
N 1980 390 2020 390 {lab=VDD}
N 3320 350 3320 430 {
lab=VDD}
N 3320 460 3360 460 {lab=VDD}
N 3360 390 3360 460 {lab=VDD}
N 3320 390 3360 390 {lab=VDD}
N 2340 460 2340 510 {lab=BGR_V_TOP}
N 2340 510 2850 510 {lab=BGR_V_TOP}
N 3320 720 3420 720 {lab=BGR_V_OUT}
N 2220 730 2400 730 {lab=BGR_Vin+}
N 2020 730 2180 730 {lab=BGR_Vin-}
N 1860 1150 1980 1150 {lab=GND}
N 2400 1100 2400 1150 {lab=GND}
N 2020 1100 2020 1150 {lab=GND}
N 1810 460 1810 500 {lab=BGR_V_TOP}
N 1610 560 1610 650 {lab=BGR_start_up}
N 1610 350 1610 430 {
lab=VDD}
N 1570 460 1610 460 {lab=VDD}
N 1570 390 1570 460 {lab=VDD}
N 1570 390 1610 390 {lab=VDD}
N 1610 490 1610 560 {lab=BGR_start_up}
N 1810 460 1900 460 {lab=BGR_V_TOP}
N 1900 460 1900 510 {lab=BGR_V_TOP}
N 1900 510 2140 510 {lab=BGR_V_TOP}
N 1610 530 1770 530 {lab=BGR_start_up}
N 1610 1150 1860 1150 {lab=GND}
N 2200 460 2200 600 {lab=BGR_V_TOP}
N 2140 460 2140 510 {lab=BGR_V_TOP}
N 1810 680 2020 680 {lab=BGR_Vin-}
N 1570 750 1610 750 {lab=GND}
N 1570 680 1570 750 {lab=GND}
N 1570 680 1610 680 {lab=GND}
N 1610 710 1610 780 {lab=GND}
N 1610 1070 1610 1150 {lab=GND}
N 1810 530 1850 530 {lab=VDD}
N 1850 480 1850 530 {lab=VDD}
N 1610 780 1610 1070 {lab=GND}
N 1650 460 1810 460 {lab=BGR_V_TOP}
N 1610 620 1670 620 {lab=BGR_start_up}
N 1670 620 1670 680 {lab=BGR_start_up}
N 1650 680 1670 680 {lab=BGR_start_up}
N 1810 560 1810 680 {lab=BGR_Vin-}
N 2020 490 2020 1040 {lab=BGR_Vin-}
N 1860 780 1860 930 {lab=BGR_Vin-}
N 2400 490 2400 930 {lab=BGR_Vin+}
N 2700 780 2700 930 {lab=BGR_Vin+}
N 3320 490 3320 850 {lab=BGR_V_OUT}
N 2210 180 2210 270 {lab=VDD}
N 2210 1150 2210 1260 {lab=GND}
N 1800 960 1840 960 {lab=GND}
N 2340 960 2380 960 {lab=GND}
N 2640 960 2680 960 {lab=GND}
N 3260 880 3300 880 {lab=GND}
N 2120 670 2140 670 {lab=GND}
N 2260 670 2280 670 {lab=VDD}
N 2210 270 2210 350 {
lab=VDD}
N 1610 270 1610 350 {lab=VDD}
N 1610 270 2210 270 {lab=VDD}
N 1850 270 1850 480 {lab=VDD}
N 2020 350 2400 350 {lab=VDD}
N 3180 460 3280 460 {lab=BGR_V_TOP}
N 2130 -680 2260 -680 {lab=V1_CM}
N 3180 -680 3180 -640 {lab=V1_CM}
N 3180 -590 3180 -550 {lab=Vin+}
N 2130 -680 2130 -640 {lab=V1_CM}
N 2130 -590 2130 -550 {lab=Vin-}
C {simulator_commands_shown.sym} 430 -750 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.xm1.msky130_fd_pr__nfet_01v8[vth]
+@m.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.xm2.msky130_fd_pr__nfet_01v8[vth]
+@m.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.xm3.msky130_fd_pr__nfet_01v8[vth]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[vth]
+@m.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.xm5.msky130_fd_pr__pfet_01v8[vth]
+@m.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm7.msky130_fd_pr__pfet_01v8[vth]
+@m.xm8.msky130_fd_pr__pfet_01v8[gm]
+@m.xm8.msky130_fd_pr__pfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__nfet_01v8[gm]
+@m.xm10.msky130_fd_pr__nfet_01v8[vth]
+@m.xm11.msky130_fd_pr__nfet_01v8[gm]
+@m.xm11.msky130_fd_pr__nfet_01v8[vth]
+@m.xm12.msky130_fd_pr__nfet_01v8[gm]
+@m.xm12.msky130_fd_pr__nfet_01v8[vth]
+@m.xm13.msky130_fd_pr__nfet_01v8[gm]
+@m.xm13.msky130_fd_pr__nfet_01v8[vth]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__pfet_01v8[gm]
+@m.xm15.msky130_fd_pr__pfet_01v8[vth]
+@m.xm16.msky130_fd_pr__pfet_01v8[gm]
+@m.xm16.msky130_fd_pr__pfet_01v8[vth]
+@m.xm17.msky130_fd_pr__pfet_01v8[gm]
+@m.xm17.msky130_fd_pr__pfet_01v8[vth]
+@m.xm18.msky130_fd_pr__pfet_01v8[gm]
+@m.xm18.msky130_fd_pr__pfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__pfet_01v8[gm]
+@m.xm20.msky130_fd_pr__pfet_01v8[vth]
+@m.xm21.msky130_fd_pr__nfet_01v8[gm]
+@m.xm21.msky130_fd_pr__nfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__nfet_01v8[gm]
+@m.xm26.msky130_fd_pr__nfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__nfet_01v8[gm]
+@m.xm28.msky130_fd_pr__nfet_01v8[vth]
+@m.xm29.msky130_fd_pr__nfet_01v8[gm]
+@m.xm29.msky130_fd_pr__nfet_01v8[vth]
+@m.xm30.msky130_fd_pr__nfet_01v8[gm]
+@m.xm30.msky130_fd_pr__nfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__nfet_01v8[gm]
+@m.xm33.msky130_fd_pr__nfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]

.ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.2 1.28 0.001
  * dc VDD 0 1.8 0.9
  * tran 0.4u 3m
  tran 0.4n 3u
  * tran 1n 12u
  * ac dec 20 1 1T
  remzerovec
  write tb_opamp_1st_stage_4.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc

"}
C {sky130_fd_pr/corner.sym} 690 -1300 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/vsource.sym} 2820 260 0 0 {name=VDD value=1.8 savecurrent=false
* "pwl(0 0 500ns 0 1000ns 1.8)"}
C {devices/gnd.sym} 2820 290 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 2820 230 0 0 {name=l1 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 2280 -680 0 0 {name=M1
W=36
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3070 -680 0 1 {name=M2
W=36
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2320 -1290 0 1 {name=M3
W=36
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3030 -1290 0 0 {name=M4
W=36
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2320 -1650 0 1 {name=M5
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3030 -1650 0 0 {name=M6
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2320 -2070 0 1 {name=M7
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3030 -2070 0 0 {name=M8
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 2480 -2280 0 0 {name=l2 lab=VDD}
C {lab_wire.sym} 2470 -2070 0 0 {name=p1 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 2470 -1650 0 0 {name=p5 sig_type=std_logic lab=Vb2}
C {lab_wire.sym} 2510 -1290 0 0 {name=p6 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/nfet_01v8.sym} 2580 -420 0 0 {name=M9
W=40
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 2600 -300 0 1 {name=l5 lab=GND}
C {devices/gnd.sym} 2130 -490 0 0 {name=l6 lab=GND}
C {lab_wire.sym} 2600 -560 0 0 {name=p10 sig_type=std_logic lab=V_p}
C {sky130_fd_pr/nfet_01v8.sym} 1320 -420 0 1 {name=M10
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 1300 -300 0 0 {name=l9 lab=GND}
C {lab_wire.sym} 2300 -420 0 0 {name=p11 sig_type=std_logic lab=VGS9}
C {isource.sym} 1300 -1060 0 0 {name=I0 value=100u}
C {vdd.sym} 1300 -1150 0 0 {name=l10 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 1120 -680 0 0 {name=M11
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1490 -680 0 1 {name=M12
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2580 -830 0 0 {name=M13
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2580 -970 0 0 {name=M14
W=1
L=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 2600 -1890 0 0 {name=I1 value=20u}
C {lab_pin.sym} 2600 -900 0 1 {name=p9 sig_type=std_logic lab=VS14}
C {lab_pin.sym} 2300 -940 0 1 {name=p13 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 2300 -1480 0 0 {name=p14 sig_type=std_logic lab=X}
C {lab_wire.sym} 1300 -560 0 1 {name=p15 sig_type=std_logic lab=V_p_mir}
C {sky130_fd_pr/pfet_01v8.sym} 630 -1910 0 1 {name=M15
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1410 -1910 0 1 {name=M16
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 630 -2120 0 1 {name=M17
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1410 -2120 0 1 {name=M18
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 810 -2330 0 0 {name=l7 lab=VDD}
C {lab_pin.sym} 1510 -2120 0 1 {name=p16 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 730 -1910 0 1 {name=p17 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 1590 -1910 0 1 {name=p18 sig_type=std_logic lab=Vb2}
C {isource.sym} 610 -1730 0 0 {name=I2 value=50u}
C {gnd.sym} 610 -1700 0 1 {name=l11 lab=GND}
C {isource.sym} 1390 -1730 0 0 {name=I3 value=50u}
C {gnd.sym} 1390 -1700 0 1 {name=l12 lab=GND}
C {lab_pin.sym} 610 -2040 0 1 {name=p19 sig_type=std_logic lab=V1}
C {lab_pin.sym} 1390 -2040 0 1 {name=p20 sig_type=std_logic lab=V2}
C {devices/ngspice_get_value.sym} 500 -2120 0 1 {name=r5 node=v(@m.xm17.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 500 -1950 0 1 {name=r6 node=v(@m.xm15.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1280 -2110 0 1 {name=r3 node=v(@m.xm18.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1280 -1940 0 1 {name=r4 node=v(@m.xm16.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 2300 -1900 0 1 {name=p2 sig_type=std_logic lab=VD7}
C {devices/ngspice_get_value.sym} 2250 -1580 0 1 {name=r7 node=v(@m.xm5.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 3050 -1480 0 1 {name=p3 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 6060 -1030 0 0 {name=M19
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6060 -1370 0 0 {name=M20
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 6080 -930 0 0 {name=I4 value=20u}
C {vdd.sym} 6080 -1110 0 0 {name=l4 lab=VDD}
C {devices/gnd.sym} 6080 -840 0 0 {name=l8 lab=GND}
C {isource.sym} 6080 -1470 0 0 {name=I5 value=20u}
C {vdd.sym} 6080 -1560 0 0 {name=l13 lab=VDD}
C {devices/gnd.sym} 6080 -1290 0 0 {name=l14 lab=GND}
C {lab_pin.sym} 5840 -1210 0 0 {name=p21 sig_type=std_logic lab=X}
C {lab_pin.sym} 6900 -1210 0 1 {name=p22 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 6260 -1420 1 0 {name=R8
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 6260 -1440 2 1 {name=l19 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 6260 -980 1 1 {name=R9
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 6260 -960 0 0 {name=l20 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 6490 -1420 3 1 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 6490 -1440 2 0 {name=l21 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 6490 -980 3 0 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 6490 -960 0 1 {name=l22 lab=GND}
C {lab_wire.sym} 6380 -1210 0 0 {name=p23 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 6690 -1030 0 1 {name=M21
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6690 -1370 0 1 {name=M22
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 6670 -930 0 1 {name=I6 value=20u}
C {vdd.sym} 6670 -1110 0 1 {name=l15 lab=VDD}
C {devices/gnd.sym} 6670 -840 0 1 {name=l16 lab=GND}
C {isource.sym} 6670 -1470 0 1 {name=I7 value=20u}
C {vdd.sym} 6670 -1560 0 1 {name=l17 lab=VDD}
C {devices/gnd.sym} 6670 -1290 0 1 {name=l18 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 5070 -510 0 1 {name=M23
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4790 -510 0 0 {name=M24
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 4090 -270 0 0 {name=I8 value=20u}
C {vdd.sym} 4930 -770 0 0 {name=l23 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 5030 -330 0 0 {name=M25
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4830 -330 0 1 {name=M26
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4930 -200 0 0 {name=l24 lab=GND}
C {lab_pin.sym} 4680 -510 0 0 {name=p24 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 3060 -420 0 1 {name=p25 sig_type=std_logic lab=err_opamp_out}
C {lab_pin.sym} 5050 -430 0 1 {name=p26 sig_type=std_logic lab=err_opamp_mir}
C {devices/vsource.sym} 6920 -880 0 1 {name=VDD1 value=0.9 savecurrent=false
}
C {devices/gnd.sym} 6920 -850 0 1 {name=l25 lab=GND}
C {lab_pin.sym} 6920 -970 0 1 {name=p28 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 5170 -510 0 1 {name=p27 sig_type=std_logic lab=V_tot}
C {lab_wire.sym} 4890 -610 0 0 {name=p29 sig_type=std_logic lab=V_err_p}
C {sky130_fd_pr/pfet_01v8.sym} 4910 -690 0 0 {name=M28
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 3040 -450 0 1 {name=r12 node=v(@m.xm27.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2280 -640 2 0 {name=r13 node=v(@m.xm1.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 3950 -510 0 0 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4230 -510 0 1 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 4090 -770 0 1 {name=l26 lab=VDD}
C {lab_pin.sym} 4340 -510 0 1 {name=p30 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 3840 -510 0 0 {name=p31 sig_type=std_logic lab=V_tot}
C {lab_wire.sym} 4130 -610 0 1 {name=p32 sig_type=std_logic lab=V_err_mir_p}
C {sky130_fd_pr/pfet_01v8.sym} 4110 -690 0 1 {name=M31
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4090 -190 0 0 {name=l27 lab=GND}
C {devices/ngspice_get_value.sym} 1390 -440 0 0 {name=r14 node=v(@m.xm10.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1540 -610 2 1 {name=r15 node=v(@m.xm12.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 4580 -690 0 1 {name=p33 sig_type=std_logic lab=V_gate}
C {lab_pin.sym} 3050 -940 0 0 {name=p34 sig_type=std_logic lab=VD2}
C {lab_pin.sym} 3050 -1900 0 0 {name=p35 sig_type=std_logic lab=VD6}
C {lab_wire.sym} 4660 -340 2 1 {name=p36 sig_type=std_logic lab=err_opamp_out}
C {devices/gnd.sym} 3180 -490 0 0 {name=l32 lab=GND}
C {devices/vsource.sym} 2130 -520 0 1 {name=V2 value="sin(0.2 -0.001 1Meg)" savecurrent=false
* 1.24
* "sin(1.04 -0.001 1k)"}
C {lab_wire.sym} 1030 -680 0 0 {name=p4 sig_type=std_logic lab=Vin-}
C {lab_wire.sym} 1580 -680 0 1 {name=p7 sig_type=std_logic lab=Vin+}
C {lab_wire.sym} 2960 -1650 0 0 {name=p12 sig_type=std_logic lab=Vb2}
C {devices/ngspice_get_value.sym} 2530 -450 0 1 {name=r16 node=v(@m.xm9.msky130_fd_pr__nfet_01v8[vth])
descr="vth="
nf=20}
C {lab_wire.sym} 2470 -830 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {devices/vsource.sym} 3180 -520 0 0 {name=V1 value="sin(0.2 0.001 1Meg)" savecurrent=false
* "1.24 AC 1"
* 1.24
* "sin(1.04 0.001 1k)"}
C {devices/ngspice_get_value.sym} 2680 -1020 0 0 {name=r17 node=v(@m.xm14.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2680 -870 0 0 {name=r18 node=v(@m.xm13.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 2330 -3030 0 1 {name=M32
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3050 -3030 0 0 {name=M33
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2330 -3390 0 1 {name=M34
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3050 -3390 0 0 {name=M35
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2460 -3390 0 1 {name=p39 sig_type=std_logic lab=X}
C {devices/ngspice_get_value.sym} 2260 -3340 2 0 {name=r1 node=v(@m.xm34.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 2920 -3390 0 0 {name=p40 sig_type=std_logic lab=Y}
C {lab_pin.sym} 2200 -3220 0 0 {name=p38 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 3180 -3220 0 1 {name=p41 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 2690 -3550 0 0 {name=l28 lab=VDD}
C {devices/gnd.sym} 2690 -2770 0 0 {name=l29 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2470 -3150 1 1 {name=R2
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 2470 -3130 0 0 {name=l30 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2910 -3150 3 0 {name=R19
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 2910 -3130 0 1 {name=l31 lab=GND}
C {lab_wire.sym} 2690 -3030 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {devices/ngspice_get_value.sym} 2258.850436985131 -3080 0 1 {name=r20 node=v(@m.xm32.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {vdd.sym} 2690 -3240 0 0 {name=l33 lab=VDD}
C {isource.sym} 2690 -2930 0 0 {name=I9 value=2u}
C {devices/ngspice_get_value.sym} 2340 -1180 0 0 {name=r21 node=v(@m.xm3.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 2920 -420 0 1 {name=M27
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6790 -980 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 6760 -1420 0 1 {name=p45 sig_type=std_logic lab=V_1}
C {devices/lab_pin.sym} 2400 1020 2 0 {name=p46 sig_type=std_logic lab=BGR_Vbe2}
C {sky130_fd_pr/pnp_05v5.sym} 2000 1070 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 2380 1070 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=6
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2040 460 0 1 {name=M36
W=16
L=0.6
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2380 460 0 0 {name=M37
W=16
L=0.6
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 460 0 0 {name=M38
W=16
L=0.6
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2610 510 2 0 {name=p48 sig_type=std_logic lab=BGR_V_TOP}
C {lab_wire.sym} 2300 730 2 0 {name=p49 sig_type=std_logic lab=BGR_Vin+}
C {lab_wire.sym} 2110 730 2 1 {name=p50 sig_type=std_logic lab=BGR_Vin-}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2400 960 0 0 {name=R22
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2700 960 0 0 {name=R23
L=33.6
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1860 960 0 0 {name=R24
L=33.6
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 3320 880 0 0 {name=R25
L=36.87
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 1630 680 0 1 {name=M39
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1630 460 0 1 {name=M40
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1610 530 2 1 {name=p51 sig_type=std_logic lab=BGR_start_up}
C {lab_wire.sym} 1810 460 0 0 {name=p53 sig_type=std_logic lab=BGR_V_TOP}
C {sky130_fd_pr/pfet_01v8.sym} 1790 530 0 0 {name=M41
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/foss/designs/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_dummy.sym} 2200 670 1 1 {name=x1}
C {lab_wire.sym} 3180 460 2 1 {name=p62 sig_type=std_logic lab=BGR_V_TOP}
C {vdd.sym} 2210 180 0 0 {name=l34 lab=VDD}
C {gnd.sym} 2210 1260 0 0 {name=l35 lab=GND}
C {vdd.sym} 3320 350 0 0 {name=l36 lab=VDD}
C {gnd.sym} 3320 1150 0 0 {name=l37 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3180 -610 0 0 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2130 -610 0 0 {name=C2 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {lab_pin.sym} 3180 -570 0 1 {name=p8 sig_type=std_logic lab=Vin+}
C {lab_pin.sym} 2130 -570 0 0 {name=p42 sig_type=std_logic lab=Vin-}
C {lab_wire.sym} 3180 -680 0 1 {name=p54 sig_type=std_logic lab=V1_CM}
C {lab_wire.sym} 2130 -680 0 0 {name=p55 sig_type=std_logic lab=V1_CM}
C {lab_pin.sym} 3420 720 0 1 {name=p56 sig_type=std_logic lab=BGR_V_OUT}
C {vdd.sym} 2280 670 0 0 {name=l38 lab=VDD}
C {gnd.sym} 2340 960 0 1 {name=l39 lab=GND}
C {gnd.sym} 2640 960 0 1 {name=l40 lab=GND}
C {gnd.sym} 2120 670 0 1 {name=l41 lab=GND}
C {gnd.sym} 1800 960 0 1 {name=l42 lab=GND}
C {gnd.sym} 3260 880 0 1 {name=l43 lab=GND}
C {lab_wire.sym} 1810 680 2 1 {name=p52 sig_type=std_logic lab=BGR_Vin-}
