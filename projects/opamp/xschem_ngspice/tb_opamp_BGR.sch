v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 2880 -860 3490 -310 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.7


color="5 6 9 11 4"
node="v_out
vin+
vin-
v_top
vdd"}
B 2 1760 -2010 1920 -1890 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.1


color=6
node=v_out}
B 2 1080 -1760 1310 -1580 {flags=graph

y2=1.9739002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.18609979



node="vdd
vin-
vin+"
color="7 6 4"}
B 2 1080 -1340 1310 -1200 {flags=graph

y2=1.7e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-6.5e-10




color="6 7"
node="i(vmeas)
i(vmeas1)"}
B 2 2190 -860 2800 -310 {flags=graph

y2=2.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.3



color=7
node=v_out}
B 2 1620 -2440 1950 -2190 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=1.5e-135



color=7
node="\\"vdd vin+ -\\""}
B 2 1540 -860 2150 -310 {flags=graph

y2=0.00025526552
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-1.015528e-05




color=6
node=@m.xm2.msky130_fd_pr__pfet_01v8[gm]}
B 2 900 -860 1510 -310 {flags=graph

y2=6.1e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0




color=7
node=i(@m.xm2.msky130_fd_pr__pfet_01v8[id])}
B 2 1080 -1550 1310 -1370 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.63




color="7 6 12"
node="start_up
v_top
v_out"}
B 2 1980 -2440 2310 -2190 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-1




color=6
node="\\"@m.xm2.msky130_fd_pr__pfet_01v8[vth] @m.xm2.msky130_fd_pr__pfet_01v8[vds] @m.xm2.msky130_fd_pr__pfet_01v8[vgs] - +\\""}
B 2 1260 -2440 1590 -2190 {flags=graph

y2=1.3390474
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.10095256



color=7
node="\\"vdd v_top -\\""}
B 2 1620 -2710 1950 -2460 {flags=graph

y2=1.3390474
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.10095256



color=7
node=v_out}
B 2 1980 -2710 2310 -2460 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-1.1



color="6 7"
node="\\"vdd v_top @m.xm2.msky130_fd_pr__pfet_01v8[vth] + -\\"

\\"@m.xm2.msky130_fd_pr__pfet_01v8[vth] v_top vin+ - +\\""}
B 2 1080 -2010 1310 -1870 {flags=graph

y2=8.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=8.8e-28





color=6
node=i(@m.xm4.msky130_fd_pr__pfet_01v8[id])}
B 2 5140 -1510 5750 -960 {flags=graph

y2=0.88
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.7



color="5 17"
node="x
y"}
B 2 5840 -1510 6450 -960 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.38




color="12 17"
node="v_out_x
v_out_y"}
B 2 5830 -2180 6440 -1630 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
B 2 5140 -890 5750 -340 {flags=graph

y2=0.17
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.18



color=7
node="\\"x y -\\""}
B 2 5840 -890 6450 -340 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-1.1



color=6
node="\\"v_out_x v_out_y -\\""}
B 2 4890 -4370 5240 -4110 {flags=graph

y2=0.20113202
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.19851058





color="6 7"
node="opamp_vin-
opamp_vin+"}
B 2 4890 -4070 5240 -3810 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.03







color="6 7"
node="v_cm+
v_cm-"}
B 2 8900 -3970 9510 -3420 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.38




color="6 7"
node="v_out_x
v_out_y"}
B 2 5350 -4370 5700 -4110 {flags=graph

y2=0.002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.002





color=6
node="\\"opamp_vin- opamp_vin+ - \\""}
B 2 5350 -4070 5700 -3810 {flags=graph

y2=0.0025
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.0027







color=6
node="\\"v_cm+ v_cm- - \\""}
B 2 4890 -3760 5240 -3500 {flags=graph

y2=0.842
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.832








color="6 7"
node="v4_p1
v4_p2"
autoload=0}
B 2 4500 -1510 5110 -960 {flags=graph

y2=0.2014275
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19874315




color="6 7"
node="opamp_vin+
opamp_vin-"}
B 2 3940 -4170 4290 -3910 {flags=graph

y2=0.74522849
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.74516947






color=6
node=v4}
N 1560 -1160 1940 -1160 {
lab=GND}
N 1520 -1240 1520 -1160 {
lab=GND}
N 1900 -1240 1900 -1160 {
lab=GND}
N 1520 -1160 1560 -1160 {
lab=GND}
N 1600 -1850 1740 -1850 {
lab=V_TOP}
N 1740 -1850 1900 -1850 {
lab=V_TOP}
N 1560 -2040 1560 -1880 {
lab=VDD}
N 1560 -2040 1940 -2040 {
lab=VDD}
N 1940 -2040 1940 -1880 {
lab=VDD}
N 1940 -2040 2350 -2040 {
lab=VDD}
N 1400 -1530 1560 -1530 {
lab=Vin-}
N 1940 -1320 1940 -1270 {lab=Vbe2}
N 2130 -1320 2130 -1160 {lab=GND}
N 1400 -1320 1400 -1160 {lab=GND}
N 1940 -1530 2130 -1530 {lab=Vin+}
N 1940 -1160 2130 -1160 {lab=GND}
N 2350 -1400 2350 -1160 {lab=GND}
N 2130 -1160 2350 -1160 {lab=GND}
N 1940 -1850 1980 -1850 {lab=VDD}
N 1980 -1920 1980 -1850 {lab=VDD}
N 1520 -1850 1560 -1850 {lab=VDD}
N 1520 -1920 1520 -1850 {lab=VDD}
N 2350 -2040 2350 -1880 {
lab=VDD}
N 2350 -1850 2390 -1850 {lab=VDD}
N 2390 -1920 2390 -1850 {lab=VDD}
N 2350 -1920 2390 -1920 {lab=VDD}
N 1880 -1850 1880 -1800 {lab=V_TOP}
N 1880 -1800 2290 -1800 {lab=V_TOP}
N 2290 -1850 2290 -1800 {lab=V_TOP}
N 2290 -1850 2310 -1850 {lab=V_TOP}
N 2350 -1660 2450 -1660 {lab=V_OUT}
N 1760 -1600 1940 -1600 {lab=Vin+}
N 1560 -1600 1720 -1600 {lab=Vin-}
N 1400 -1160 1520 -1160 {lab=GND}
N 1940 -1210 1940 -1160 {lab=GND}
N 1560 -1210 1560 -1160 {lab=GND}
N 1940 -1420 1940 -1380 {lab=#net1}
N 1560 -1430 1560 -1270 {lab=#net2}
N 2350 -1530 2350 -1460 {lab=#net3}
N 2350 -1820 2350 -1590 {lab=V_OUT}
N 1940 -1820 1940 -1770 {lab=#net4}
N 1560 -1820 1560 -1770 {lab=#net5}
N 1350 -1850 1350 -1810 {lab=V_TOP}
N 1010 -1750 1010 -1660 {lab=start_up}
N 1010 -2040 1010 -1880 {
lab=VDD}
N 970 -1850 1010 -1850 {lab=VDD}
N 970 -1920 970 -1850 {lab=VDD}
N 970 -1920 1010 -1920 {lab=VDD}
N 1010 -1820 1010 -1750 {lab=start_up}
N 1010 -2040 1560 -2040 {lab=VDD}
N 1350 -1850 1440 -1850 {lab=V_TOP}
N 1440 -1850 1440 -1800 {lab=V_TOP}
N 1440 -1800 1680 -1800 {lab=V_TOP}
N 1010 -1780 1310 -1780 {lab=start_up}
N 1010 -1160 1400 -1160 {lab=GND}
N 1740 -1850 1740 -1730 {lab=V_TOP}
N 1560 -1710 1560 -1490 {lab=Vin-}
N 1940 -1710 1940 -1480 {lab=Vin+}
N 1680 -1850 1680 -1800 {lab=V_TOP}
N 1350 -1630 1560 -1630 {lab=Vin-}
N 970 -1560 1010 -1560 {lab=GND}
N 970 -1630 970 -1560 {lab=GND}
N 970 -1630 1010 -1630 {lab=GND}
N 1010 -1600 1010 -1530 {lab=GND}
N 1010 -1240 1010 -1160 {lab=GND}
N 1350 -1780 1390 -1780 {lab=VDD}
N 1350 -1650 1350 -1630 {lab=Vin-}
N 1350 -1750 1350 -1710 {lab=#net6}
N 1010 -1530 1010 -1240 {lab=GND}
N 2130 -1430 2130 -1380 {lab=#net7}
N 2130 -1530 2130 -1490 {lab=Vin+}
N 1400 -1530 1400 -1490 {lab=Vin-}
N 1400 -1430 1400 -1380 {lab=#net8}
N 1050 -1850 1350 -1850 {lab=V_TOP}
N 1010 -1690 1070 -1690 {lab=start_up}
N 1070 -1690 1070 -1630 {lab=start_up}
N 1050 -1630 1070 -1630 {lab=start_up}
N 1520 -1920 1560 -1920 {lab=VDD}
N 1940 -1920 1980 -1920 {lab=VDD}
N 1390 -2040 1390 -1780 {lab=VDD}
N 6270 -2470 6270 -2380 {lab=V_p}
N 6270 -2380 7020 -2380 {lab=V_p}
N 7020 -2470 7020 -2380 {lab=V_p}
N 6270 -3080 6270 -2530 {lab=VD1}
N 7020 -3080 7020 -2530 {lab=VD2}
N 6310 -3110 6980 -3110 {lab=Vb1}
N 6270 -3440 6270 -3140 {lab=X}
N 7020 -3440 7020 -3140 {lab=Y}
N 6270 -3860 6270 -3500 {lab=VD7}
N 7020 -3860 7020 -3500 {lab=VD6}
N 6310 -3470 6980 -3470 {lab=Vb2}
N 7020 -3470 7090 -3470 {lab=VD6}
N 7090 -3540 7090 -3470 {lab=VD6}
N 7020 -3540 7090 -3540 {lab=VD6}
N 6200 -3470 6270 -3470 {lab=VD7}
N 6200 -3540 6200 -3470 {lab=VD7}
N 6200 -3540 6270 -3540 {lab=VD7}
N 6270 -4040 6270 -3920 {lab=VDD}
N 7020 -4040 7020 -3920 {lab=VDD}
N 6310 -3890 6980 -3890 {lab=Vb3}
N 7020 -3890 7090 -3890 {lab=VDD}
N 7090 -3960 7090 -3890 {lab=VDD}
N 7020 -3960 7090 -3960 {lab=VDD}
N 6200 -3890 6270 -3890 {lab=VDD}
N 6200 -3960 6200 -3890 {lab=VDD}
N 6200 -3960 6270 -3960 {lab=VDD}
N 6270 -4040 7020 -4040 {lab=VDD}
N 6220 -3110 6270 -3110 {lab=GND}
N 6220 -3110 6220 -3050 {lab=GND}
N 6220 -3050 7080 -3050 {lab=GND}
N 7080 -3110 7080 -3050 {lab=GND}
N 7020 -3110 7080 -3110 {lab=GND}
N 6450 -4100 6450 -4040 {lab=VDD}
N 6720 -2500 7020 -2500 {lab=GND}
N 6270 -2500 6720 -2500 {lab=GND}
N 6570 -2380 6570 -2270 {lab=V_p}
N 6720 -2500 6720 -2240 {lab=GND}
N 6570 -2240 6720 -2240 {lab=GND}
N 6570 -2210 6570 -2120 {lab=GND}
N 6570 -2160 6720 -2160 {lab=GND}
N 6720 -2240 6720 -2160 {lab=GND}
N 7060 -2500 7150 -2500 {lab=V_cm+}
N 4670 -2380 4670 -2270 {lab=V_p_mir}
N 4590 -2240 4670 -2240 {lab=GND}
N 4670 -2210 4670 -2120 {lab=GND}
N 4590 -2160 4670 -2160 {lab=GND}
N 4590 -2240 4590 -2160 {lab=GND}
N 4710 -2240 6530 -2240 {lab=VGS9}
N 4670 -3160 4670 -3100 {lab=VDD}
N 4750 -2500 4840 -2500 {lab=GND}
N 4510 -2500 4750 -2500 {lab=GND}
N 4510 -2470 4510 -2380 {lab=V_p_mir}
N 4510 -2380 4840 -2380 {lab=V_p_mir}
N 4840 -2470 4840 -2380 {lab=V_p_mir}
N 4590 -2500 4590 -2240 {lab=GND}
N 4510 -2650 4510 -2530 {lab=VGS9}
N 4510 -2650 4840 -2650 {lab=VGS9}
N 4840 -2650 4840 -2530 {lab=VGS9}
N 4670 -2850 4670 -2650 {lab=VGS9}
N 4880 -2500 4950 -2500 {lab=V_cm-}
N 4400 -2500 4470 -2500 {lab=V_cm+}
N 4670 -2770 5070 -2770 {lab=VGS9}
N 5070 -2770 5070 -2240 {lab=VGS9}
N 6570 -2760 6570 -2680 {lab=VS14}
N 6570 -2790 6720 -2790 {lab=GND}
N 6570 -2650 6720 -2650 {lab=GND}
N 6570 -2620 6570 -2380 {lab=V_p}
N 6570 -3110 6570 -2820 {lab=Vb1}
N 6440 -2650 6530 -2650 {lab=Vb1}
N 6440 -2910 6440 -2650 {lab=Vb1}
N 6440 -2910 6570 -2910 {lab=Vb1}
N 6440 -2790 6530 -2790 {lab=Vb1}
N 6570 -3680 6570 -3110 {lab=Vb1}
N 6570 -4040 6570 -3740 {lab=VDD}
N 6090 -4520 6090 -4400 {lab=Vb2}
N 6870 -4520 6870 -4400 {lab=Vb3}
N 6090 -4730 6090 -4580 {lab=V1}
N 6870 -4730 6870 -4580 {lab=V2}
N 6800 -4550 6870 -4550 {lab=V2}
N 6800 -4620 6800 -4550 {lab=V2}
N 6800 -4620 6870 -4620 {lab=V2}
N 6020 -4550 6090 -4550 {lab=V1}
N 6020 -4620 6020 -4550 {lab=V1}
N 6020 -4620 6090 -4620 {lab=V1}
N 6090 -4910 6090 -4790 {lab=VDD}
N 6870 -4910 6870 -4790 {lab=VDD}
N 6800 -4760 6870 -4760 {lab=VDD}
N 6800 -4830 6800 -4760 {lab=VDD}
N 6800 -4830 6870 -4830 {lab=VDD}
N 6020 -4760 6090 -4760 {lab=VDD}
N 6020 -4830 6020 -4760 {lab=VDD}
N 6020 -4830 6090 -4830 {lab=VDD}
N 6290 -4970 6290 -4910 {lab=VDD}
N 6090 -4910 6870 -4910 {lab=VDD}
N 6130 -4760 6210 -4760 {lab=Vb2}
N 6130 -4550 6210 -4550 {lab=Vb2}
N 6910 -4760 6990 -4760 {lab=Vb3}
N 6990 -4760 6990 -4450 {lab=Vb3}
N 6870 -4450 6990 -4450 {lab=Vb3}
N 6210 -4760 6210 -4450 {lab=Vb2}
N 6090 -4450 6210 -4450 {lab=Vb2}
N 6910 -4550 7070 -4550 {lab=Vb2}
N 10050 -2930 10050 -2880 {lab=VDD}
N 10050 -2720 10050 -2660 {lab=GND}
N 10050 -2820 10050 -2780 {lab=#net9}
N 10050 -3160 10050 -3110 {lab=GND}
N 10050 -3270 10050 -3220 {lab=#net10}
N 9930 -3190 9930 -2850 {lab=X}
N 10680 -3190 10750 -3190 {lab=Y}
N 10750 -3190 10750 -2850 {lab=Y}
N 10680 -2850 10750 -2850 {lab=Y}
N 9810 -3030 9930 -3030 {lab=X}
N 10750 -3030 10870 -3030 {lab=Y}
N 10490 -3240 10640 -3240 {lab=V_1}
N 10490 -2800 10640 -2800 {lab=V_2}
N 10050 -3190 10130 -3190 {lab=VDD}
N 10050 -3350 10130 -3350 {lab=VDD}
N 10050 -3380 10050 -3320 {lab=VDD}
N 10130 -3350 10130 -3190 {lab=VDD}
N 10050 -2690 10130 -2690 {lab=GND}
N 10050 -2850 10130 -2850 {lab=GND}
N 10130 -2850 10130 -2690 {lab=GND}
N 10640 -2930 10640 -2880 {lab=VDD}
N 10640 -2720 10640 -2660 {lab=GND}
N 10640 -2820 10640 -2780 {lab=V_2}
N 10640 -3160 10640 -3110 {lab=GND}
N 10640 -3270 10640 -3220 {lab=V_1}
N 10560 -3190 10640 -3190 {lab=VDD}
N 10560 -3350 10640 -3350 {lab=VDD}
N 10640 -3380 10640 -3320 {lab=VDD}
N 10560 -3350 10560 -3190 {lab=VDD}
N 10560 -2690 10640 -2690 {lab=GND}
N 10560 -2850 10640 -2850 {lab=GND}
N 10560 -2850 10560 -2690 {lab=GND}
N 10350 -3240 10350 -2800 {lab=V_tot}
N 9020 -2430 9020 -2360 {lab=V_err_p}
N 8780 -2430 9020 -2430 {lab=V_err_p}
N 8780 -2430 8780 -2360 {lab=V_err_p}
N 8900 -2480 8900 -2430 {lab=V_err_p}
N 8900 -2590 8900 -2540 {lab=VDD}
N 9020 -2300 9020 -2180 {lab=err_opamp_mir}
N 8780 -2300 8780 -2180 {lab=err_opamp_out}
N 9020 -2120 9020 -2070 {lab=GND}
N 8780 -2070 9020 -2070 {lab=GND}
N 8780 -2120 8780 -2070 {lab=GND}
N 8900 -2070 8900 -2020 {lab=GND}
N 8780 -2330 9020 -2330 {lab=VDD}
N 8820 -2150 8980 -2150 {lab=err_opamp_mir}
N 8740 -2150 8780 -2150 {lab=GND}
N 8740 -2150 8740 -2100 {lab=GND}
N 8740 -2100 8780 -2100 {lab=GND}
N 9020 -2150 9060 -2150 {lab=GND}
N 9060 -2150 9060 -2100 {lab=GND}
N 9020 -2100 9060 -2100 {lab=GND}
N 8920 -2230 9020 -2230 {lab=err_opamp_mir}
N 8920 -2230 8920 -2150 {lab=err_opamp_mir}
N 10350 -2800 10350 -2330 {lab=V_tot}
N 8650 -2330 8740 -2330 {lab=V_ref}
N 6720 -2240 6870 -2240 {lab=GND}
N 6720 -2160 6870 -2160 {lab=GND}
N 6870 -2210 6870 -2160 {lab=GND}
N 6870 -2380 6870 -2270 {lab=V_p}
N 9060 -2330 10350 -2330 {lab=V_tot}
N 9550 -3100 9550 -3040 {lab=V_ref}
N 8900 -2510 8940 -2510 {lab=VDD}
N 8940 -2570 8940 -2510 {lab=VDD}
N 8900 -2570 8940 -2570 {lab=VDD}
N 8940 -2510 8940 -2330 {lab=VDD}
N 7940 -2430 7940 -2360 {lab=V_err_mir_p}
N 7940 -2430 8180 -2430 {lab=V_err_mir_p}
N 8180 -2430 8180 -2360 {lab=V_err_mir_p}
N 8060 -2480 8060 -2430 {lab=V_err_mir_p}
N 8060 -2590 8060 -2540 {lab=VDD}
N 7940 -2330 8180 -2330 {lab=VDD}
N 8220 -2330 8310 -2330 {lab=V_ref}
N 8020 -2510 8060 -2510 {lab=VDD}
N 8020 -2570 8020 -2510 {lab=VDD}
N 8020 -2570 8060 -2570 {lab=VDD}
N 8020 -2510 8020 -2330 {lab=VDD}
N 8100 -2510 8860 -2510 {lab=V_gate}
N 7940 -2300 7940 -2240 {lab=V_gate}
N 7940 -2240 8180 -2240 {lab=V_gate}
N 8180 -2300 8180 -2240 {lab=V_gate}
N 8060 -2240 8060 -2120 {lab=V_gate}
N 7810 -2330 7900 -2330 {lab=V_tot}
N 8060 -2060 8060 -2010 {lab=GND}
N 8500 -2510 8500 -2180 {lab=V_gate}
N 8060 -2180 8500 -2180 {lab=V_gate}
N 6910 -2240 7610 -2240 {lab=err_opamp_out}
N 7610 -2240 7610 -1880 {lab=err_opamp_out}
N 7610 -1880 8630 -1880 {lab=err_opamp_out}
N 8630 -2250 8630 -1880 {lab=err_opamp_out}
N 8630 -2250 8780 -2250 {lab=err_opamp_out}
N 6720 -2790 6720 -2500 {lab=GND}
N 6720 -3050 6720 -2790 {lab=GND}
N 7750 -3890 7750 -3590 {lab=V_OUT_X}
N 8510 -3890 8510 -3590 {lab=V_OUT_Y}
N 8510 -3920 8580 -3920 {lab=VDD}
N 8580 -3990 8580 -3920 {lab=VDD}
N 8510 -3990 8580 -3990 {lab=VDD}
N 7680 -3920 7750 -3920 {lab=VDD}
N 7680 -3990 7750 -3990 {lab=VDD}
N 7680 -3990 7680 -3920 {lab=VDD}
N 7750 -4020 7750 -3950 {lab=VDD}
N 8510 -4020 8510 -3950 {lab=VDD}
N 7750 -3530 7750 -3360 {lab=GND}
N 8510 -3530 8510 -3360 {lab=GND}
N 8510 -3490 8580 -3490 {lab=GND}
N 8580 -3560 8580 -3490 {lab=GND}
N 8510 -3560 8580 -3560 {lab=GND}
N 7680 -3490 7750 -3490 {lab=GND}
N 7680 -3560 7750 -3560 {lab=GND}
N 7680 -3560 7680 -3490 {lab=GND}
N 7790 -3920 7900 -3920 {lab=X}
N 8360 -3920 8470 -3920 {lab=Y}
N 7640 -3750 7750 -3750 {lab=V_OUT_X}
N 8510 -3750 8620 -3750 {lab=V_OUT_Y}
N 7750 -4020 8510 -4020 {lab=VDD}
N 7750 -3360 8510 -3360 {lab=GND}
N 8130 -4080 8130 -4020 {lab=VDD}
N 8130 -3360 8130 -3300 {lab=GND}
N 8130 -3560 8130 -3490 {lab=V_b}
N 8130 -3430 8130 -3360 {lab=GND}
N 8380 -3680 8510 -3680 {lab=V_OUT_Y}
N 8130 -3560 8470 -3560 {lab=V_b}
N 8190 -3680 8320 -3680 {lab=V_b}
N 8190 -3680 8190 -3560 {lab=V_b}
N 7750 -3680 7880 -3680 {lab=V_OUT_X}
N 7940 -3680 8070 -3680 {lab=V_b}
N 7790 -3560 8130 -3560 {lab=V_b}
N 8070 -3680 8070 -3560 {lab=V_b}
N 10260 -2800 10430 -2800 {lab=V_tot}
N 10260 -3240 10430 -3240 {lab=V_tot}
N 10050 -3240 10200 -3240 {lab=#net10}
N 10050 -2800 10200 -2800 {lab=#net9}
N 9930 -3190 10010 -3190 {lab=X}
N 9930 -2850 10010 -2850 {lab=X}
N 6100 -2500 6230 -2500 {lab=V_cm-}
N 10640 -2800 10760 -2800 {lab=V_2}
N 10640 -3240 10730 -3240 {lab=V_1}
N 6270 -2380 7020 -2380 {lab=V_p}
N 5750 -2500 6100 -2500 {lab=V_cm-}
N 4950 -2500 5750 -2500 {lab=V_cm-}
N 4400 -2600 5750 -2600 {lab=V_cm+}
N 4400 -2600 4400 -2500 {lab=V_cm+}
N 7150 -2600 7150 -2500 {lab=V_cm+}
N 5750 -2600 7150 -2600 {lab=V_cm+}
N 7150 -2440 7150 -2370 {lab=opamp_Vin+}
N 4670 -3040 4670 -2850 {lab=VGS9}
N 3740 -4760 3740 -4700 {lab=VDD}
N 3740 -4280 3740 -4170 {lab=GND}
N 3740 -4390 3820 -4390 {lab=v3}
N 3820 -4390 3820 -4310 {lab=v3}
N 3780 -4310 3820 -4310 {lab=v3}
N 3690 -4310 3740 -4310 {lab=GND}
N 3820 -4310 3960 -4310 {lab=v3}
N 3690 -4310 3690 -4250 {lab=GND}
N 3690 -4250 3740 -4250 {lab=GND}
N 4560 -4310 4610 -4310 {lab=GND}
N 4610 -4310 4610 -4250 {lab=GND}
N 4560 -4250 4610 -4250 {lab=GND}
N 4020 -4310 4520 -4310 {lab=v5}
N 4560 -4580 4560 -4340 {lab=V_cm+}
N 4560 -4900 4560 -4800 {lab=VDD}
N 4200 -4570 4200 -4470 {lab=opamp_Vin-}
N 4200 -4410 4200 -4310 {lab=v5}
N 3740 -4640 3740 -4510 {lab=vg1}
N 3740 -4450 3740 -4340 {lab=v3}
N 3780 -4480 3990 -4480 {lab=vg1}
N 3990 -4480 3990 -4350 {lab=vg1}
N 3740 -4560 3820 -4560 {lab=vg1}
N 3820 -4560 3820 -4480 {lab=vg1}
N 3740 -4250 3990 -4250 {lab=GND}
N 3990 -4310 3990 -4250 {lab=GND}
N 3690 -4480 3690 -4310 {lab=GND}
N 3690 -4480 3740 -4480 {lab=GND}
N 4560 -4770 4630 -4770 {lab=VDD}
N 4630 -4840 4630 -4770 {lab=VDD}
N 4560 -4840 4630 -4840 {lab=VDD}
N 4420 -4690 4420 -4640 {lab=v4_p1}
N 4420 -4810 4420 -4690 {lab=v4_p1}
N 4420 -4900 4420 -4870 {lab=VDD}
N 4560 -4280 4560 -4250 {lab=GND}
N 4560 -4490 4610 -4490 {lab=V_cm+}
N 4420 -4640 4460 -4640 {lab=v4_p1}
N 4560 -4740 4560 -4580 {lab=V_cm+}
N 4520 -4640 4560 -4640 {lab=V_cm+}
N 4420 -4900 4560 -4900 {lab=VDD}
N 4420 -4770 4520 -4770 {lab=v4_p1}
N 3740 -3930 3740 -3870 {lab=VDD}
N 3740 -3450 3740 -3340 {lab=GND}
N 3740 -3560 3820 -3560 {lab=v4}
N 3820 -3560 3820 -3480 {lab=v4}
N 3780 -3480 3820 -3480 {lab=v4}
N 3690 -3480 3740 -3480 {lab=GND}
N 3820 -3480 3960 -3480 {lab=v4}
N 3690 -3480 3690 -3420 {lab=GND}
N 3690 -3420 3740 -3420 {lab=GND}
N 4560 -3480 4610 -3480 {lab=GND}
N 4610 -3480 4610 -3420 {lab=GND}
N 4560 -3420 4610 -3420 {lab=GND}
N 4020 -3480 4520 -3480 {lab=v6}
N 4560 -3750 4560 -3510 {lab=V_cm-}
N 4560 -4070 4560 -3970 {lab=VDD}
N 4200 -3740 4200 -3640 {lab=opamp_Vin+}
N 4200 -3580 4200 -3480 {lab=v6}
N 3740 -3810 3740 -3680 {lab=vg2}
N 3740 -3620 3740 -3510 {lab=v4}
N 3780 -3650 3990 -3650 {lab=vg2}
N 3990 -3650 3990 -3520 {lab=vg2}
N 3740 -3730 3820 -3730 {lab=vg2}
N 3820 -3730 3820 -3650 {lab=vg2}
N 3740 -3420 3990 -3420 {lab=GND}
N 3990 -3480 3990 -3420 {lab=GND}
N 3690 -3650 3690 -3480 {lab=GND}
N 3690 -3650 3740 -3650 {lab=GND}
N 4560 -3940 4630 -3940 {lab=VDD}
N 4630 -4010 4630 -3940 {lab=VDD}
N 4560 -4010 4630 -4010 {lab=VDD}
N 4420 -3860 4420 -3810 {lab=v4_p2}
N 4420 -3980 4420 -3860 {lab=v4_p2}
N 4420 -4070 4420 -4040 {lab=VDD}
N 4560 -3450 4560 -3420 {lab=GND}
N 4560 -3660 4610 -3660 {lab=V_cm-}
N 4420 -3810 4460 -3810 {lab=v4_p2}
N 4560 -3910 4560 -3750 {lab=V_cm-}
N 4520 -3810 4560 -3810 {lab=V_cm-}
N 4420 -4070 4560 -4070 {lab=VDD}
N 4420 -3940 4520 -3940 {lab=v4_p2}
N 4340 -3810 4420 -3810 {lab=v4_p2}
N 4340 -4640 4420 -4640 {lab=v4_p1}
N 6100 -2420 6100 -2370 {lab=opamp_Vin-}
C {devices/vsource.sym} 2420 -2290 0 0 {name=VDD value="pwl(0 0 1us 0 2us 1.8)" savecurrent=false
* 1.8}
C {devices/gnd.sym} 2420 -2260 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 2420 -2320 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 870 -2530 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/gnd.sym} 1740 -1160 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 1800 -1660 1 0 {name=l5 lab=VDD}
C {devices/gnd.sym} 1680 -1660 1 0 {name=l8 lab=GND
W=4}
C {devices/lab_pin.sym} 1940 -1290 2 0 {name=p5 sig_type=std_logic lab=Vbe2}
C {devices/vdd.sym} 1740 -2040 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} 2450 -1660 2 0 {name=p4 sig_type=std_logic lab=V_OUT
}
C {sky130_fd_pr/pnp_05v5.sym} 1540 -1240 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1920 -1240 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {devices/gnd.sym} 1920 -1350 1 0 {name=l6 lab=GND}
C {devices/gnd.sym} 2110 -1350 1 0 {name=l7 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1580 -1850 0 1 {name=M1
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1920 -1850 0 0 {name=M2
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2330 -1850 0 0 {name=M3
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1380 -1350 1 0 {name=l10 lab=GND}
C {lab_wire.sym} 2090 -1800 2 0 {name=p2 sig_type=std_logic lab=V_TOP}
C {lab_wire.sym} 1840 -1600 2 0 {name=p6 sig_type=std_logic lab=Vin+}
C {lab_wire.sym} 1650 -1600 2 1 {name=p1 sig_type=std_logic lab=Vin-}
C {ammeter.sym} 1560 -1460 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {ammeter.sym} 1940 -1450 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2350 -1560 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1940 -1350 0 0 {name=R1
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2130 -1350 0 0 {name=R2
L=28.95
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1400 -1350 0 0 {name=R3
L=28.95
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {ammeter.sym} 1560 -1740 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0
L=1}
C {ammeter.sym} 1940 -1740 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 1030 -1630 0 1 {name=M5
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1030 -1850 0 1 {name=M6
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1010 -1780 2 1 {name=p7 sig_type=std_logic lab=start_up}
C {lab_wire.sym} 1350 -1630 2 1 {name=p3 sig_type=std_logic lab=Vin-}
C {lab_wire.sym} 1350 -1850 0 0 {name=p8 sig_type=std_logic lab=V_TOP}
C {ammeter.sym} 1350 -1680 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0
L=1}
C {sky130_fd_pr/pfet_01v8.sym} 1330 -1780 0 0 {name=M4
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ammeter.sym} 1400 -1460 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {ammeter.sym} 2130 -1460 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {opamp_bandgap_2.sym} 1740 -1660 1 1 {name=x1}
C {ngspice_get_value.sym} 1900 -1780 2 0 {name=r5 node=v(@m.xm2.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 6250 -2500 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7040 -2500 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -3110 0 1 {name=M9
W=32
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7000 -3110 0 0 {name=M10
W=32
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6290 -3470 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7000 -3470 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6290 -3890 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7000 -3890 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 6450 -4100 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 6440 -3890 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 6440 -3470 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 6550 -2240 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 6570 -2120 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 6100 -2310 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 4690 -2240 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 4670 -2120 0 0 {name=l14 lab=GND}
C {isource.sym} 4670 -3070 0 0 {name=I0 value=100u}
C {vdd.sym} 4670 -3160 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 4490 -2500 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4860 -2500 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6550 -2650 0 0 {name=M19
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6550 -2790 0 0 {name=M20
W=1
L=2.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 6570 -3710 0 0 {name=I1 value=10u}
C {lab_pin.sym} 6270 -3300 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 6110 -4550 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6890 -4550 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6110 -4760 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6890 -4760 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 6290 -4970 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 6990 -4760 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 6210 -4550 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 7070 -4550 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {isource.sym} 6090 -4370 0 0 {name=I2 value=50u}
C {gnd.sym} 6090 -4340 0 1 {name=l17 lab=GND}
C {isource.sym} 6870 -4370 0 0 {name=I3 value=50u}
C {gnd.sym} 6870 -4340 0 1 {name=l18 lab=GND}
C {lab_pin.sym} 7020 -3300 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 10030 -2850 0 0 {name=M25
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10030 -3190 0 0 {name=M26
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 10050 -2750 0 0 {name=I4 value=20u}
C {vdd.sym} 10050 -2930 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 10050 -2660 0 0 {name=l20 lab=GND}
C {isource.sym} 10050 -3290 0 0 {name=I5 value=20u}
C {vdd.sym} 10050 -3380 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 10050 -3110 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 9810 -3030 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 10870 -3030 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10230 -3240 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10230 -3260 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10230 -2800 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10230 -2780 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10460 -3240 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 10460 -3260 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10460 -2800 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10460 -2780 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 10350 -3030 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 10660 -2850 0 1 {name=M27
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10660 -3190 0 1 {name=M28
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 10640 -2750 0 1 {name=I6 value=20u}
C {vdd.sym} 10640 -2930 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 10640 -2660 0 1 {name=l28 lab=GND}
C {isource.sym} 10640 -3290 0 1 {name=I7 value=20u}
C {vdd.sym} 10640 -3380 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 10640 -3110 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 9040 -2330 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8760 -2330 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 8060 -2090 0 0 {name=I8 value=20u}
C {vdd.sym} 8900 -2590 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 9000 -2150 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8800 -2150 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8900 -2020 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 8650 -2330 0 0 {name=p28 sig_type=std_logic lab=V_ref}
C {devices/vsource.sym} 9550 -3010 0 1 {name=VDD1 value=0.9 savecurrent=false
}
C {devices/gnd.sym} 9550 -2980 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 9550 -3100 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 9140 -2330 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8880 -2510 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7920 -2330 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8200 -2330 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 8060 -2590 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 8310 -2330 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 7810 -2330 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8080 -2510 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8060 -2010 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 7150 -2310 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 6100 -2340 0 1 {name=V2 value="sin(0.2 -0.001 1Meg)" savecurrent=false
* 1.24
* }
C {devices/vsource.sym} 7150 -2340 0 0 {name=V1 value="sin(0.2 0.001 1Meg)" savecurrent=false
* "1.24 AC 1"
* 1.24
* 0.001 }
C {sky130_fd_pr/nfet_01v8.sym} 7770 -3560 0 1 {name=M37
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8490 -3560 0 0 {name=M38
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7770 -3920 0 1 {name=M39
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8490 -3920 0 0 {name=M40
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7900 -3920 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 8360 -3920 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 7640 -3750 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 8620 -3750 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 8130 -4080 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 8130 -3300 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 7910 -3680 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 7910 -3660 0 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8350 -3680 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8350 -3660 0 1 {name=l40 lab=GND}
C {isource.sym} 8130 -3460 0 0 {name=I9 value=2u}
C {sky130_fd_pr/nfet_01v8.sym} 6890 -2240 0 1 {name=M41
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7150 -2390 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 6100 -2390 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {simulator_commands_shown.sym} 340 -2590 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm1.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm1.msky130_fd_pr__pfet_01v8[vds]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm2.msky130_fd_pr__pfet_01v8[vds]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__pfet_01v8[gm]
+@m.xm10.msky130_fd_pr__pfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gm]
+@m.xm11.msky130_fd_pr__pfet_01v8[vth]
+@m.xm12.msky130_fd_pr__pfet_01v8[gm]
+@m.xm12.msky130_fd_pr__pfet_01v8[vth]
+@m.xm13.msky130_fd_pr__pfet_01v8[gm]
+@m.xm13.msky130_fd_pr__pfet_01v8[vth]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__nfet_01v8[gm]
+@m.xm15.msky130_fd_pr__nfet_01v8[vth]
+@m.xm16.msky130_fd_pr__nfet_01v8[gm]
+@m.xm16.msky130_fd_pr__nfet_01v8[vth]
+@m.xm17.msky130_fd_pr__nfet_01v8[gm]
+@m.xm17.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__pfet_01v8[gm]
+@m.xm21.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[gm]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[gm]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]
+@m.xm36.msky130_fd_pr__pfet_01v8[gm]
+@m.xm36.msky130_fd_pr__pfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm39.msky130_fd_pr__pfet_01v8[gm]
+@m.xm39.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm41.msky130_fd_pr__nfet_01v8[gm]
+@m.xm41.msky130_fd_pr__nfet_01v8[vth]
+@m.xm42.msky130_fd_pr__nfet_01v8[gm]
+@m.xm42.msky130_fd_pr__nfet_01v8[vth]
+@m.xm43.msky130_fd_pr__nfet_01v8[gm]
+@m.xm43.msky130_fd_pr__nfet_01v8[vth]

.ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.238 1.242 0.0001
  * dc VDD 0 1.8 0.9
  * dc temp -40 120 10 VDD 0 4.0 0.2
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  * tran 0.4n 3u
  tran 1ns 10us
  * ac dec 20 1 1T
  remzerovec
  write tb_opamp_BGR.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc


"}
C {lab_wire.sym} 6570 -2380 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 6570 -2720 0 1 {name=p14 sig_type=std_logic lab=VS14}
C {lab_pin.sym} 6270 -2760 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 7020 -2760 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 6440 -2650 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6000 -2240 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 4670 -2380 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 6270 -3700 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 7020 -3700 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 6090 -4670 0 1 {name=p29 sig_type=std_logic lab=V1}
C {lab_pin.sym} 6870 -4670 0 1 {name=p30 sig_type=std_logic lab=V2}
C {lab_pin.sym} 9020 -2250 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 8860 -2430 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 8100 -2430 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 8550 -2510 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 8630 -2160 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 10760 -2800 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 10730 -3240 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 8130 -3560 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 6440 -3110 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {devices/gnd.sym} 2330 -1430 1 0 {name=l9 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2350 -1430 0 0 {name=R4
L=31.26
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {vdd.sym} 3740 -4750 0 0 {name=l43 lab=VDD}
C {isource.sym} 3740 -4670 0 0 {name=I10 value=5u}
C {gnd.sym} 3740 -4180 0 1 {name=l44 lab=GND}
C {gnd.sym} 4560 -4250 0 0 {name=l45 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4200 -4440 2 0 {name=C3 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {lab_wire.sym} 3820 -4390 0 1 {name=p54 sig_type=std_logic lab=v3}
C {lab_wire.sym} 4200 -4310 2 0 {name=p55 sig_type=std_logic lab=v5}
C {lab_wire.sym} 3990 -4480 0 1 {name=p56 sig_type=std_logic lab=vg1}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -4480 0 1 {name=M44
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -4310 0 1 {name=M45
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3990 -4330 3 1 {name=M46
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4540 -4310 0 0 {name=M47
W=2
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4540 -4770 0 0 {name=M48
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 4560 -4900 0 1 {name=l47 lab=VDD}
C {devices/gnd.sym} 4490 -4620 0 0 {name=l49 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 4490 -4640 3 0 {name=R25
L=11.1
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_pin.sym} 4200 -4570 0 0 {name=p58 sig_type=std_logic lab=opamp_Vin-}
C {lab_wire.sym} 4420 -4640 2 1 {name=p59 sig_type=std_logic lab=v4_p1}
C {vdd.sym} 3740 -3920 0 0 {name=l46 lab=VDD}
C {isource.sym} 3740 -3840 0 0 {name=I11 value=5u}
C {gnd.sym} 3740 -3350 0 1 {name=l48 lab=GND}
C {gnd.sym} 4560 -3420 0 0 {name=l50 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 4200 -3610 2 0 {name=C5 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {lab_wire.sym} 3820 -3560 0 1 {name=p51 sig_type=std_logic lab=v4}
C {lab_wire.sym} 4200 -3480 2 0 {name=p60 sig_type=std_logic lab=v6}
C {lab_wire.sym} 3990 -3650 0 1 {name=p61 sig_type=std_logic lab=vg2}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -3650 0 1 {name=M49
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -3480 0 1 {name=M50
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3990 -3500 3 1 {name=M51
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4540 -3480 0 0 {name=M52
W=2
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4540 -3940 0 0 {name=M53
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 4560 -4070 0 1 {name=l51 lab=VDD}
C {devices/gnd.sym} 4490 -3790 0 0 {name=l52 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 4490 -3810 3 0 {name=R7
L=11.1
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_pin.sym} 4200 -3740 0 0 {name=p63 sig_type=std_logic lab=opamp_Vin+}
C {lab_wire.sym} 4420 -3810 2 1 {name=p64 sig_type=std_logic lab=v4_p2}
C {gnd.sym} 4280 -3810 1 0 {name=l53 lab=GND}
C {isource.sym} 4310 -3810 1 0 {name=I12 value=5u}
C {gnd.sym} 4280 -4640 1 0 {name=l54 lab=GND}
C {isource.sym} 4310 -4640 1 0 {name=I13 value=5u}
C {lab_wire.sym} 5640 -2600 0 0 {name=p67 sig_type=std_logic lab=V_cm+}
C {lab_wire.sym} 5940 -2500 0 0 {name=p65 sig_type=std_logic lab=V_cm-}
C {lab_wire.sym} 4610 -4490 0 1 {name=p66 sig_type=std_logic lab=V_cm+}
C {lab_wire.sym} 4610 -3660 0 1 {name=p68 sig_type=std_logic lab=V_cm-}
