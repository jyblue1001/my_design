v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 2290 -1350 2900 -800 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.7


color="5 6 9 11 4"
node="v_out
vin+
vin-
v_top
vdd"}
B 2 1170 -2500 1330 -2380 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.1


color=6
node=v_out}
B 2 490 -2250 720 -2070 {flags=graph

y2=1.9739002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.18609979



node="vdd
vin-
vin+"
color="7 6 4"}
B 2 490 -1830 720 -1690 {flags=graph

y2=1.7e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-6.5e-10




color="6 7"
node="i(vmeas)
i(vmeas1)"}
B 2 1600 -1350 2210 -800 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.1



color=7
node=v_out}
B 2 1030 -2930 1360 -2680 {flags=graph

y2=1.7
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=1.5e-135



color=7
node="\\"vdd vin+ -\\""}
B 2 950 -1350 1560 -800 {flags=graph

y2=0.00025526552
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-1.015528e-05




color=6
node=@m.xm2.msky130_fd_pr__pfet_01v8[gm]}
B 2 310 -1350 920 -800 {flags=graph

y2=6.1e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0




color=7
node=i(@m.xm2.msky130_fd_pr__pfet_01v8[id])}
B 2 490 -2040 720 -1860 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.63




color="7 6 12"
node="start_up
v_top
v_out"}
B 2 1390 -2930 1720 -2680 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-1




color=6
node="\\"@m.xm2.msky130_fd_pr__pfet_01v8[vth] @m.xm2.msky130_fd_pr__pfet_01v8[vds] @m.xm2.msky130_fd_pr__pfet_01v8[vgs] - +\\""}
B 2 670 -2930 1000 -2680 {flags=graph

y2=1.3390474
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.10095256



color=7
node="\\"vdd v_top -\\""}
B 2 1030 -3200 1360 -2950 {flags=graph

y2=1.3390474
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-0.10095256



color=7
node=v_out}
B 2 1390 -3200 1720 -2950 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=0.6
























y1=-1.1



color="6 7"
node="\\"vdd v_top @m.xm2.msky130_fd_pr__pfet_01v8[vth] + -\\"

\\"@m.xm2.msky130_fd_pr__pfet_01v8[vth] v_top vin+ - +\\""}
B 2 490 -2500 720 -2360 {flags=graph

y2=8.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=8.8e-28





color=6
node=i(@m.xm4.msky130_fd_pr__pfet_01v8[id])}
B 2 4480 -810 5090 -260 {flags=graph

y2=1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.68



color="5 17"
node="x
y"}
B 2 5180 -810 5790 -260 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.58




color="12 17"
node="v_out_x
v_out_y"}
B 2 4910 -1480 5520 -930 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
B 2 4480 -190 5090 360 {flags=graph

y2=0.26
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.21



color=7
node="\\"x y -\\""}
B 2 5180 -190 5790 360 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-1.4



color=6
node="\\"v_out_x v_out_y -\\""}
B 2 4240 -2240 4590 -1980 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=1e-05
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
N 970 -1650 1350 -1650 {
lab=GND}
N 930 -1730 930 -1650 {
lab=GND}
N 1310 -1730 1310 -1650 {
lab=GND}
N 930 -1650 970 -1650 {
lab=GND}
N 1010 -2340 1150 -2340 {
lab=V_TOP}
N 1150 -2340 1310 -2340 {
lab=V_TOP}
N 970 -2530 970 -2370 {
lab=VDD}
N 970 -2530 1350 -2530 {
lab=VDD}
N 1350 -2530 1350 -2370 {
lab=VDD}
N 1350 -2530 1760 -2530 {
lab=VDD}
N 810 -2020 970 -2020 {
lab=Vin-}
N 1350 -1810 1350 -1760 {lab=Vbe2}
N 1540 -1810 1540 -1650 {lab=GND}
N 810 -1810 810 -1650 {lab=GND}
N 1350 -2020 1540 -2020 {lab=Vin+}
N 1350 -1650 1540 -1650 {lab=GND}
N 1760 -1890 1760 -1650 {lab=GND}
N 1540 -1650 1760 -1650 {lab=GND}
N 1350 -2340 1390 -2340 {lab=VDD}
N 1390 -2410 1390 -2340 {lab=VDD}
N 930 -2340 970 -2340 {lab=VDD}
N 930 -2410 930 -2340 {lab=VDD}
N 1760 -2530 1760 -2370 {
lab=VDD}
N 1760 -2340 1800 -2340 {lab=VDD}
N 1800 -2410 1800 -2340 {lab=VDD}
N 1760 -2410 1800 -2410 {lab=VDD}
N 1290 -2340 1290 -2290 {lab=V_TOP}
N 1290 -2290 1700 -2290 {lab=V_TOP}
N 1700 -2340 1700 -2290 {lab=V_TOP}
N 1700 -2340 1720 -2340 {lab=V_TOP}
N 1760 -2150 1860 -2150 {lab=V_OUT}
N 1170 -2090 1350 -2090 {lab=Vin+}
N 970 -2090 1130 -2090 {lab=Vin-}
N 810 -1650 930 -1650 {lab=GND}
N 1350 -1700 1350 -1650 {lab=GND}
N 970 -1700 970 -1650 {lab=GND}
N 1350 -1910 1350 -1870 {lab=#net1}
N 970 -1920 970 -1760 {lab=#net2}
N 1760 -2020 1760 -1950 {lab=#net3}
N 1760 -2310 1760 -2080 {lab=V_OUT}
N 1350 -2310 1350 -2260 {lab=#net4}
N 970 -2310 970 -2260 {lab=#net5}
N 760 -2340 760 -2300 {lab=V_TOP}
N 420 -2240 420 -2150 {lab=start_up}
N 420 -2530 420 -2370 {
lab=VDD}
N 380 -2340 420 -2340 {lab=VDD}
N 380 -2410 380 -2340 {lab=VDD}
N 380 -2410 420 -2410 {lab=VDD}
N 420 -2310 420 -2240 {lab=start_up}
N 420 -2530 970 -2530 {lab=VDD}
N 760 -2340 850 -2340 {lab=V_TOP}
N 850 -2340 850 -2290 {lab=V_TOP}
N 850 -2290 1090 -2290 {lab=V_TOP}
N 420 -2270 720 -2270 {lab=start_up}
N 420 -1650 810 -1650 {lab=GND}
N 1150 -2340 1150 -2220 {lab=V_TOP}
N 970 -2200 970 -1980 {lab=Vin-}
N 1350 -2200 1350 -1970 {lab=Vin+}
N 1090 -2340 1090 -2290 {lab=V_TOP}
N 760 -2120 970 -2120 {lab=Vin-}
N 380 -2050 420 -2050 {lab=GND}
N 380 -2120 380 -2050 {lab=GND}
N 380 -2120 420 -2120 {lab=GND}
N 420 -2090 420 -2020 {lab=GND}
N 420 -1730 420 -1650 {lab=GND}
N 760 -2270 800 -2270 {lab=VDD}
N 760 -2140 760 -2120 {lab=Vin-}
N 760 -2240 760 -2200 {lab=#net6}
N 420 -2020 420 -1730 {lab=GND}
N 1540 -1920 1540 -1870 {lab=#net7}
N 1540 -2020 1540 -1980 {lab=Vin+}
N 810 -2020 810 -1980 {lab=Vin-}
N 810 -1920 810 -1870 {lab=#net8}
N 460 -2340 760 -2340 {lab=V_TOP}
N 420 -2180 480 -2180 {lab=start_up}
N 480 -2180 480 -2120 {lab=start_up}
N 460 -2120 480 -2120 {lab=start_up}
N 930 -2410 970 -2410 {lab=VDD}
N 1350 -2410 1390 -2410 {lab=VDD}
N 800 -2530 800 -2270 {lab=VDD}
N 5350 -1770 5350 -1680 {lab=V_p}
N 5350 -1680 6100 -1680 {lab=V_p}
N 6100 -1770 6100 -1680 {lab=V_p}
N 5350 -2380 5350 -1830 {lab=VD1}
N 6100 -2380 6100 -1830 {lab=VD2}
N 5390 -2410 6060 -2410 {lab=Vb1}
N 5350 -2740 5350 -2440 {lab=X}
N 6100 -2740 6100 -2440 {lab=Y}
N 5350 -3160 5350 -2800 {lab=VD7}
N 6100 -3160 6100 -2800 {lab=VD6}
N 5390 -2770 6060 -2770 {lab=Vb2}
N 6100 -2770 6170 -2770 {lab=VD6}
N 6170 -2840 6170 -2770 {lab=VD6}
N 6100 -2840 6170 -2840 {lab=VD6}
N 5280 -2770 5350 -2770 {lab=VD7}
N 5280 -2840 5280 -2770 {lab=VD7}
N 5280 -2840 5350 -2840 {lab=VD7}
N 5350 -3340 5350 -3220 {lab=VDD}
N 6100 -3340 6100 -3220 {lab=VDD}
N 5390 -3190 6060 -3190 {lab=Vb3}
N 6100 -3190 6170 -3190 {lab=VDD}
N 6170 -3260 6170 -3190 {lab=VDD}
N 6100 -3260 6170 -3260 {lab=VDD}
N 5280 -3190 5350 -3190 {lab=VDD}
N 5280 -3260 5280 -3190 {lab=VDD}
N 5280 -3260 5350 -3260 {lab=VDD}
N 5350 -3340 6100 -3340 {lab=VDD}
N 5300 -2410 5350 -2410 {lab=GND}
N 5300 -2410 5300 -2350 {lab=GND}
N 5300 -2350 6160 -2350 {lab=GND}
N 6160 -2410 6160 -2350 {lab=GND}
N 6100 -2410 6160 -2410 {lab=GND}
N 5530 -3400 5530 -3340 {lab=VDD}
N 5800 -1800 6100 -1800 {lab=GND}
N 5350 -1800 5800 -1800 {lab=GND}
N 5650 -1680 5650 -1570 {lab=V_p}
N 5800 -1800 5800 -1540 {lab=GND}
N 5650 -1540 5800 -1540 {lab=GND}
N 5650 -1510 5650 -1420 {lab=GND}
N 5650 -1460 5800 -1460 {lab=GND}
N 5800 -1540 5800 -1460 {lab=GND}
N 6140 -1800 6230 -1800 {lab=v_cm_-}
N 3750 -1680 3750 -1570 {lab=V_p_mir}
N 3670 -1540 3750 -1540 {lab=GND}
N 3750 -1510 3750 -1420 {lab=GND}
N 3670 -1460 3750 -1460 {lab=GND}
N 3670 -1540 3670 -1460 {lab=GND}
N 3790 -1540 5610 -1540 {lab=VGS9}
N 3750 -2460 3750 -2400 {lab=VDD}
N 3830 -1800 3920 -1800 {lab=GND}
N 3590 -1800 3830 -1800 {lab=GND}
N 3590 -1770 3590 -1680 {lab=V_p_mir}
N 3590 -1680 3920 -1680 {lab=V_p_mir}
N 3920 -1770 3920 -1680 {lab=V_p_mir}
N 3670 -1800 3670 -1540 {lab=GND}
N 3590 -1950 3590 -1830 {lab=VGS9}
N 3590 -1950 3920 -1950 {lab=VGS9}
N 3920 -1950 3920 -1830 {lab=VGS9}
N 3750 -2150 3750 -1950 {lab=VGS9}
N 3960 -1800 4030 -1800 {lab=v_cm_+}
N 3480 -1800 3550 -1800 {lab=v_cm_-}
N 3750 -2070 4150 -2070 {lab=VGS9}
N 4150 -2070 4150 -1540 {lab=VGS9}
N 5650 -2060 5650 -1980 {lab=VS14}
N 5650 -2090 5800 -2090 {lab=GND}
N 5650 -1950 5800 -1950 {lab=GND}
N 5650 -1920 5650 -1680 {lab=V_p}
N 5650 -2410 5650 -2120 {lab=Vb1}
N 5520 -1950 5610 -1950 {lab=Vb1}
N 5520 -2210 5520 -1950 {lab=Vb1}
N 5520 -2210 5650 -2210 {lab=Vb1}
N 5520 -2090 5610 -2090 {lab=Vb1}
N 5650 -2980 5650 -2410 {lab=Vb1}
N 5650 -3340 5650 -3040 {lab=VDD}
N 3710 -3320 3710 -3200 {lab=Vb2}
N 4490 -3320 4490 -3200 {lab=Vb3}
N 3710 -3530 3710 -3380 {lab=V1}
N 4490 -3530 4490 -3380 {lab=V2}
N 4420 -3350 4490 -3350 {lab=V2}
N 4420 -3420 4420 -3350 {lab=V2}
N 4420 -3420 4490 -3420 {lab=V2}
N 3640 -3350 3710 -3350 {lab=V1}
N 3640 -3420 3640 -3350 {lab=V1}
N 3640 -3420 3710 -3420 {lab=V1}
N 3710 -3710 3710 -3590 {lab=VDD}
N 4490 -3710 4490 -3590 {lab=VDD}
N 4420 -3560 4490 -3560 {lab=VDD}
N 4420 -3630 4420 -3560 {lab=VDD}
N 4420 -3630 4490 -3630 {lab=VDD}
N 3640 -3560 3710 -3560 {lab=VDD}
N 3640 -3630 3640 -3560 {lab=VDD}
N 3640 -3630 3710 -3630 {lab=VDD}
N 3910 -3770 3910 -3710 {lab=VDD}
N 3710 -3710 4490 -3710 {lab=VDD}
N 3750 -3560 3830 -3560 {lab=Vb2}
N 3750 -3350 3830 -3350 {lab=Vb2}
N 4530 -3560 4610 -3560 {lab=Vb3}
N 4610 -3560 4610 -3250 {lab=Vb3}
N 4490 -3250 4610 -3250 {lab=Vb3}
N 3830 -3560 3830 -3250 {lab=Vb2}
N 3710 -3250 3830 -3250 {lab=Vb2}
N 4530 -3350 4690 -3350 {lab=Vb2}
N 9130 -2230 9130 -2180 {lab=VDD}
N 9130 -2020 9130 -1960 {lab=GND}
N 9130 -2120 9130 -2080 {lab=#net9}
N 9130 -2460 9130 -2410 {lab=GND}
N 9130 -2570 9130 -2520 {lab=#net10}
N 9010 -2490 9010 -2150 {lab=X}
N 9760 -2490 9830 -2490 {lab=Y}
N 9830 -2490 9830 -2150 {lab=Y}
N 9760 -2150 9830 -2150 {lab=Y}
N 8890 -2330 9010 -2330 {lab=X}
N 9830 -2330 9950 -2330 {lab=Y}
N 9570 -2540 9720 -2540 {lab=V_1}
N 9570 -2100 9720 -2100 {lab=V_2}
N 9130 -2490 9210 -2490 {lab=VDD}
N 9130 -2650 9210 -2650 {lab=VDD}
N 9130 -2680 9130 -2620 {lab=VDD}
N 9210 -2650 9210 -2490 {lab=VDD}
N 9130 -1990 9210 -1990 {lab=GND}
N 9130 -2150 9210 -2150 {lab=GND}
N 9210 -2150 9210 -1990 {lab=GND}
N 9720 -2230 9720 -2180 {lab=VDD}
N 9720 -2020 9720 -1960 {lab=GND}
N 9720 -2120 9720 -2080 {lab=V_2}
N 9720 -2460 9720 -2410 {lab=GND}
N 9720 -2570 9720 -2520 {lab=V_1}
N 9640 -2490 9720 -2490 {lab=VDD}
N 9640 -2650 9720 -2650 {lab=VDD}
N 9720 -2680 9720 -2620 {lab=VDD}
N 9640 -2650 9640 -2490 {lab=VDD}
N 9640 -1990 9720 -1990 {lab=GND}
N 9640 -2150 9720 -2150 {lab=GND}
N 9640 -2150 9640 -1990 {lab=GND}
N 9430 -2540 9430 -2100 {lab=V_tot}
N 8100 -1730 8100 -1660 {lab=V_err_p}
N 7860 -1730 8100 -1730 {lab=V_err_p}
N 7860 -1730 7860 -1660 {lab=V_err_p}
N 7980 -1780 7980 -1730 {lab=V_err_p}
N 7980 -1890 7980 -1840 {lab=VDD}
N 8100 -1600 8100 -1480 {lab=err_opamp_mir}
N 7860 -1600 7860 -1480 {lab=err_opamp_out}
N 8100 -1420 8100 -1370 {lab=GND}
N 7860 -1370 8100 -1370 {lab=GND}
N 7860 -1420 7860 -1370 {lab=GND}
N 7980 -1370 7980 -1320 {lab=GND}
N 7860 -1630 8100 -1630 {lab=VDD}
N 7900 -1450 8060 -1450 {lab=err_opamp_mir}
N 7820 -1450 7860 -1450 {lab=GND}
N 7820 -1450 7820 -1400 {lab=GND}
N 7820 -1400 7860 -1400 {lab=GND}
N 8100 -1450 8140 -1450 {lab=GND}
N 8140 -1450 8140 -1400 {lab=GND}
N 8100 -1400 8140 -1400 {lab=GND}
N 8000 -1530 8100 -1530 {lab=err_opamp_mir}
N 8000 -1530 8000 -1450 {lab=err_opamp_mir}
N 9430 -2100 9430 -1630 {lab=V_tot}
N 7730 -1630 7820 -1630 {lab=V_ref}
N 5800 -1540 5950 -1540 {lab=GND}
N 5800 -1460 5950 -1460 {lab=GND}
N 5950 -1510 5950 -1460 {lab=GND}
N 5950 -1680 5950 -1570 {lab=V_p}
N 8140 -1630 9430 -1630 {lab=V_tot}
N 9970 -1870 9970 -1810 {lab=V_ref}
N 7980 -1810 8020 -1810 {lab=VDD}
N 8020 -1870 8020 -1810 {lab=VDD}
N 7980 -1870 8020 -1870 {lab=VDD}
N 8020 -1810 8020 -1630 {lab=VDD}
N 7020 -1730 7020 -1660 {lab=V_err_mir_p}
N 7020 -1730 7260 -1730 {lab=V_err_mir_p}
N 7260 -1730 7260 -1660 {lab=V_err_mir_p}
N 7140 -1780 7140 -1730 {lab=V_err_mir_p}
N 7140 -1890 7140 -1840 {lab=VDD}
N 7020 -1630 7260 -1630 {lab=VDD}
N 7300 -1630 7390 -1630 {lab=V_ref}
N 7100 -1810 7140 -1810 {lab=VDD}
N 7100 -1870 7100 -1810 {lab=VDD}
N 7100 -1870 7140 -1870 {lab=VDD}
N 7100 -1810 7100 -1630 {lab=VDD}
N 7180 -1810 7940 -1810 {lab=V_gate}
N 7020 -1600 7020 -1540 {lab=V_gate}
N 7020 -1540 7260 -1540 {lab=V_gate}
N 7260 -1600 7260 -1540 {lab=V_gate}
N 7140 -1540 7140 -1420 {lab=V_gate}
N 6890 -1630 6980 -1630 {lab=V_tot}
N 7140 -1360 7140 -1310 {lab=GND}
N 7580 -1810 7580 -1480 {lab=V_gate}
N 7140 -1480 7580 -1480 {lab=V_gate}
N 5990 -1540 6690 -1540 {lab=err_opamp_out}
N 6690 -1540 6690 -1180 {lab=err_opamp_out}
N 6690 -1180 7710 -1180 {lab=err_opamp_out}
N 7710 -1550 7710 -1180 {lab=err_opamp_out}
N 7710 -1550 7860 -1550 {lab=err_opamp_out}
N 5800 -2090 5800 -1800 {lab=GND}
N 5800 -2350 5800 -2090 {lab=GND}
N 6830 -3190 6830 -2890 {lab=V_OUT_X}
N 7590 -3190 7590 -2890 {lab=V_OUT_Y}
N 7590 -3220 7660 -3220 {lab=VDD}
N 7660 -3290 7660 -3220 {lab=VDD}
N 7590 -3290 7660 -3290 {lab=VDD}
N 6760 -3220 6830 -3220 {lab=VDD}
N 6760 -3290 6830 -3290 {lab=VDD}
N 6760 -3290 6760 -3220 {lab=VDD}
N 6830 -3320 6830 -3250 {lab=VDD}
N 7590 -3320 7590 -3250 {lab=VDD}
N 6830 -2830 6830 -2660 {lab=GND}
N 7590 -2830 7590 -2660 {lab=GND}
N 7590 -2790 7660 -2790 {lab=GND}
N 7660 -2860 7660 -2790 {lab=GND}
N 7590 -2860 7660 -2860 {lab=GND}
N 6760 -2790 6830 -2790 {lab=GND}
N 6760 -2860 6830 -2860 {lab=GND}
N 6760 -2860 6760 -2790 {lab=GND}
N 6870 -3220 6980 -3220 {lab=X}
N 7440 -3220 7550 -3220 {lab=Y}
N 6720 -3050 6830 -3050 {lab=V_OUT_X}
N 7590 -3050 7700 -3050 {lab=V_OUT_Y}
N 6830 -3320 7590 -3320 {lab=VDD}
N 6830 -2660 7590 -2660 {lab=GND}
N 7210 -3380 7210 -3320 {lab=VDD}
N 7210 -2660 7210 -2600 {lab=GND}
N 7210 -2860 7210 -2790 {lab=V_b}
N 7210 -2730 7210 -2660 {lab=GND}
N 7460 -2980 7590 -2980 {lab=V_OUT_Y}
N 7210 -2860 7550 -2860 {lab=V_b}
N 7270 -2980 7400 -2980 {lab=V_b}
N 7270 -2980 7270 -2860 {lab=V_b}
N 6830 -2980 6960 -2980 {lab=V_OUT_X}
N 7020 -2980 7150 -2980 {lab=V_b}
N 6870 -2860 7210 -2860 {lab=V_b}
N 7150 -2980 7150 -2860 {lab=V_b}
N 9340 -2100 9510 -2100 {lab=V_tot}
N 9340 -2540 9510 -2540 {lab=V_tot}
N 9130 -2540 9280 -2540 {lab=#net10}
N 9130 -2100 9280 -2100 {lab=#net9}
N 9010 -2490 9090 -2490 {lab=X}
N 9010 -2150 9090 -2150 {lab=X}
N 5180 -1800 5310 -1800 {lab=v_cm_+}
N 9720 -2100 9840 -2100 {lab=V_2}
N 9720 -2540 9810 -2540 {lab=V_1}
N 5350 -1680 6100 -1680 {lab=V_p}
N 4830 -1800 5180 -1800 {lab=v_cm_+}
N 4030 -1800 4830 -1800 {lab=v_cm_+}
N 3480 -1900 4830 -1900 {lab=v_cm_-}
N 3480 -1900 3480 -1800 {lab=v_cm_-}
N 6230 -1900 6230 -1800 {lab=v_cm_-}
N 4830 -1900 6230 -1900 {lab=v_cm_-}
N 5180 -1740 5180 -1670 {lab=opamp_Vin-}
N 6230 -1740 6230 -1670 {lab=opamp_Vin+}
N 3750 -2340 3750 -2150 {lab=VGS9}
N 4910 -2240 4960 -2240 {lab=v_cm_-}
N 4960 -2240 4960 -1900 {lab=v_cm_-}
N 4880 -2240 4880 -2160 {lab=GND}
N 5270 -2240 5270 -1800 {lab=v_cm_+}
N 5220 -2240 5270 -2240 {lab=v_cm_+}
N 4880 -2330 5190 -2330 {lab=VDD}
N 5190 -2330 5190 -2280 {lab=VDD}
N 4830 -2310 4830 -2240 {lab=v_out}
N 4830 -2310 5090 -2310 {lab=v_out}
N 5090 -2310 5090 -2240 {lab=v_out}
N 5090 -2240 5160 -2240 {lab=v_out}
N 4880 -2210 5190 -2210 {lab=GND}
N 5190 -2240 5190 -2210 {lab=GND}
N 4880 -2370 4880 -2280 {lab=VDD}
N 4730 -2240 4850 -2240 {lab=v_out}
C {devices/vsource.sym} 1830 -2780 0 0 {name=VDD value=1.8 savecurrent=false
* "pwl(0 0 1us 0 2us 1.8)"}
C {devices/gnd.sym} 1830 -2750 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 1830 -2810 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 280 -3020 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/gnd.sym} 1150 -1650 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 1210 -2150 1 0 {name=l5 lab=VDD}
C {devices/gnd.sym} 1090 -2150 1 0 {name=l8 lab=GND
W=4}
C {devices/lab_pin.sym} 1350 -1780 2 0 {name=p5 sig_type=std_logic lab=Vbe2}
C {devices/vdd.sym} 1150 -2530 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} 1860 -2150 2 0 {name=p4 sig_type=std_logic lab=V_OUT
}
C {sky130_fd_pr/pnp_05v5.sym} 950 -1730 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1330 -1730 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {devices/gnd.sym} 1330 -1840 1 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1520 -1840 1 0 {name=l7 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 990 -2340 0 1 {name=M1
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1330 -2340 0 0 {name=M2
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1740 -2340 0 0 {name=M3
W=16
L=0.6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 790 -1840 1 0 {name=l10 lab=GND}
C {lab_wire.sym} 1500 -2290 2 0 {name=p2 sig_type=std_logic lab=V_TOP}
C {lab_wire.sym} 1250 -2090 2 0 {name=p6 sig_type=std_logic lab=Vin+}
C {lab_wire.sym} 1060 -2090 2 1 {name=p1 sig_type=std_logic lab=Vin-}
C {ammeter.sym} 970 -1950 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {ammeter.sym} 1350 -1940 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {ammeter.sym} 1760 -2050 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1350 -1840 0 0 {name=R1
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1540 -1840 0 0 {name=R2
L=28.95
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 810 -1840 0 0 {name=R3
L=28.95
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {ammeter.sym} 970 -2230 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0
L=1}
C {ammeter.sym} 1350 -2230 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 440 -2120 0 1 {name=M5
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 440 -2340 0 1 {name=M6
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 420 -2270 2 1 {name=p7 sig_type=std_logic lab=start_up}
C {lab_wire.sym} 760 -2120 2 1 {name=p3 sig_type=std_logic lab=Vin-}
C {lab_wire.sym} 760 -2340 0 0 {name=p8 sig_type=std_logic lab=V_TOP}
C {ammeter.sym} 760 -2170 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0
L=1}
C {sky130_fd_pr/pfet_01v8.sym} 740 -2270 0 0 {name=M4
W=2
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ammeter.sym} 810 -1950 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {ammeter.sym} 1540 -1950 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {/foss/designs/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 1150 -2150 1 1 {name=x1}
C {ngspice_get_value.sym} 1310 -2270 2 0 {name=r5 node=v(@m.xm2.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 5330 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6120 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5370 -2410 0 1 {name=M9
W=32
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6080 -2410 0 0 {name=M10
W=32
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5370 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6080 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5370 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6080 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 5530 -3400 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 5520 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 5520 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 5630 -1540 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 5650 -1420 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 5180 -1610 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3770 -1540 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 3750 -1420 0 0 {name=l14 lab=GND}
C {isource.sym} 3750 -2370 0 0 {name=I0 value=100u}
C {vdd.sym} 3750 -2460 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 3570 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3940 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5630 -1950 0 0 {name=M19
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5630 -2090 0 0 {name=M20
W=1
L=2.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 5650 -3010 0 0 {name=I1 value=10u}
C {lab_pin.sym} 5350 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 3730 -3350 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4510 -3350 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3730 -3560 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4510 -3560 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3910 -3770 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 4610 -3560 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 3830 -3350 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 4690 -3350 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {isource.sym} 3710 -3170 0 0 {name=I2 value=50u}
C {gnd.sym} 3710 -3140 0 1 {name=l17 lab=GND}
C {isource.sym} 4490 -3170 0 0 {name=I3 value=50u}
C {gnd.sym} 4490 -3140 0 1 {name=l18 lab=GND}
C {lab_pin.sym} 6100 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 9110 -2150 0 0 {name=M25
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9110 -2490 0 0 {name=M26
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 9130 -2050 0 0 {name=I4 value=20u}
C {vdd.sym} 9130 -2230 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 9130 -1960 0 0 {name=l20 lab=GND}
C {isource.sym} 9130 -2590 0 0 {name=I5 value=20u}
C {vdd.sym} 9130 -2680 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 9130 -2410 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 8890 -2330 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 9950 -2330 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9310 -2540 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 9310 -2560 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9310 -2100 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 9310 -2080 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9540 -2540 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 9540 -2560 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9540 -2100 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 9540 -2080 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 9430 -2330 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 9740 -2150 0 1 {name=M27
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9740 -2490 0 1 {name=M28
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 9720 -2050 0 1 {name=I6 value=20u}
C {vdd.sym} 9720 -2230 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 9720 -1960 0 1 {name=l28 lab=GND}
C {isource.sym} 9720 -2590 0 1 {name=I7 value=20u}
C {vdd.sym} 9720 -2680 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 9720 -2410 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 8120 -1630 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7840 -1630 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 7140 -1390 0 0 {name=I8 value=20u}
C {vdd.sym} 7980 -1890 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 8080 -1450 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7880 -1450 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 7980 -1320 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 7730 -1630 0 0 {name=p28 sig_type=std_logic lab=V_ref}
C {devices/vsource.sym} 9970 -1780 0 1 {name=VDD1 value=0.9 savecurrent=false
}
C {devices/gnd.sym} 9970 -1750 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 9970 -1870 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 8220 -1630 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 7960 -1810 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7000 -1630 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7280 -1630 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 7140 -1890 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 7390 -1630 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 6890 -1630 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 7160 -1810 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 7140 -1310 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 6230 -1610 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 5180 -1640 0 1 {name=V2 value="sin(0.2 -0.001 1Meg)" savecurrent=false
* 1.24
* }
C {devices/vsource.sym} 6230 -1640 0 0 {name=V1 value="sin(1.24 0.001 1Meg)" savecurrent=false
* "1.24 AC 1"
* 1.24
* 0.001 }
C {sky130_fd_pr/nfet_01v8.sym} 6850 -2860 0 1 {name=M37
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7570 -2860 0 0 {name=M38
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6850 -3220 0 1 {name=M39
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7570 -3220 0 0 {name=M40
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6980 -3220 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 7440 -3220 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 6720 -3050 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 7700 -3050 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 7210 -3380 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 7210 -2600 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 6990 -2980 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 6990 -2960 0 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 7430 -2980 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 7430 -2960 0 1 {name=l40 lab=GND}
C {isource.sym} 7210 -2760 0 0 {name=I9 value=2u}
C {sky130_fd_pr/nfet_01v8.sym} 5970 -1540 0 1 {name=M41
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6230 -1690 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 5180 -1690 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {simulator_commands_shown.sym} -170 -3060 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm1.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm1.msky130_fd_pr__pfet_01v8[vds]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm2.msky130_fd_pr__pfet_01v8[vds]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__pfet_01v8[gm]
+@m.xm10.msky130_fd_pr__pfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gm]
+@m.xm11.msky130_fd_pr__pfet_01v8[vth]
+@m.xm12.msky130_fd_pr__pfet_01v8[gm]
+@m.xm12.msky130_fd_pr__pfet_01v8[vth]
+@m.xm13.msky130_fd_pr__pfet_01v8[gm]
+@m.xm13.msky130_fd_pr__pfet_01v8[vth]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__nfet_01v8[gm]
+@m.xm15.msky130_fd_pr__nfet_01v8[vth]
+@m.xm16.msky130_fd_pr__nfet_01v8[gm]
+@m.xm16.msky130_fd_pr__nfet_01v8[vth]
+@m.xm17.msky130_fd_pr__nfet_01v8[gm]
+@m.xm17.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__pfet_01v8[gm]
+@m.xm21.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[gm]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[gm]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]
+@m.xm36.msky130_fd_pr__pfet_01v8[gm]
+@m.xm36.msky130_fd_pr__pfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm39.msky130_fd_pr__pfet_01v8[gm]
+@m.xm39.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm41.msky130_fd_pr__nfet_01v8[gm]
+@m.xm41.msky130_fd_pr__nfet_01v8[vth]
+@m.xm42.msky130_fd_pr__nfet_01v8[gm]
+@m.xm42.msky130_fd_pr__nfet_01v8[vth]
+@m.xm43.msky130_fd_pr__nfet_01v8[gm]
+@m.xm43.msky130_fd_pr__nfet_01v8[vth]

.ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.238 1.242 0.0001
  * dc VDD 0 1.8 0.9
  * dc temp -40 120 10 VDD 0 4.0 0.2
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  * tran 0.4n 3u
  tran 1ns 10us
  * ac dec 20 1 1T
  remzerovec
  write tb_opamp_BGR.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc


"}
C {lab_wire.sym} 5650 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 5650 -2020 0 1 {name=p14 sig_type=std_logic lab=VS14}
C {lab_pin.sym} 5350 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 6100 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 5520 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 5080 -1540 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 3750 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 5350 -3000 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 6100 -3000 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 3710 -3470 0 1 {name=p29 sig_type=std_logic lab=V1}
C {lab_pin.sym} 4490 -3470 0 1 {name=p30 sig_type=std_logic lab=V2}
C {lab_pin.sym} 8100 -1550 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 7940 -1730 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 7180 -1730 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 7630 -1810 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 7710 -1460 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 9840 -2100 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 9810 -2540 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 7210 -2860 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 5520 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {devices/gnd.sym} 1740 -1920 1 0 {name=l9 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1760 -1920 0 0 {name=R4
L=31.26
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 5180 -1770 0 0 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6230 -1770 0 0 {name=C2 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 4880 -2260 3 1 {name=M42
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4880 -2160 0 0 {name=l42 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5190 -2260 3 1 {name=M43
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 4960 -2050 0 0 {name=p12 sig_type=std_logic lab=v_cm_-}
C {lab_pin.sym} 5270 -2050 0 0 {name=p49 sig_type=std_logic lab=v_cm_+}
C {devices/ngspice_get_value.sym} 4800 -2170 0 1 {name=r15 node=@m.xm42.msky130_fd_pr__nfet_01v8[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 5260 -2260 0 0 {name=r6 node=@m.xm43.msky130_fd_pr__nfet_01v8[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 4798.850436985131 -2120 0 1 {name=r20 node=v(@m.xm42.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 4730 -2240 0 0 {name=p11 sig_type=std_logic lab=v_out}
C {vdd.sym} 4880 -2370 0 0 {name=l41 lab=VDD}
