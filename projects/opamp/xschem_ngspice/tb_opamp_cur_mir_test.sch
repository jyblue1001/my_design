v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 5790 -810 6400 -260 {flags=graph

y2=0.88
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.72



color="5 17"
node="x
y"}
B 2 6490 -810 7100 -260 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.42




color="12 17"
node="v_out_x
v_out_y"}
B 2 6220 -1480 6830 -930 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
B 2 5790 -190 6400 360 {flags=graph

y2=0.15
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.15



color=7
node="\\"x y -\\""}
B 2 6490 -190 7100 360 {flags=graph

y2=0.88
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.88



color=6
node="\\"v_out_x v_out_y -\\""}
B 2 5550 -2240 5900 -1980 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
B 2 3570 -3310 3740 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 -\\""}
B 2 3550 -3530 3720 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 @m.xm1.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3200 -3530 3370 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm3.msky130_fd_pr__pfet_01v8[vth] @m.xm1.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3200 -3740 3370 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v3 -\\""}
B 2 3460 -3670 3630 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 @m.xm3.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4360 -3530 4530 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 -\\""}
B 2 3940 -3520 4110 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm4.msky130_fd_pr__pfet_01v8[vth] @m.xm2.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3940 -3690 4110 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v4 -\\""}
B 2 4360 -3680 4530 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 @m.xm4.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3190 -3310 3360 -3210 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 4360 -3290 4530 -3200 {flags=graph
y1=0.876
y2=0.896
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb4 @m.xm2.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3970 -3290 4140 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb5 - \\""}
B 2 3680 -3850 3850 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 1900 -3410 2070 -3290 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 -\\""}
B 2 1880 -3630 2050 -3540 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 @m.xm5.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2690 -3530 2860 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 -\\""}
B 2 2270 -3520 2440 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm43.msky130_fd_pr__pfet_01v8[vth] @m.xm7.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 2270 -3690 2440 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v5 -\\""}
B 2 2690 -3680 2860 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 @m.xm43.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 1520 -3410 1690 -3310 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 - \\""}
B 2 2690 -3290 2860 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb6 @m.xm6.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2300 -3290 2470 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb7 - \\""}
B 2 2010 -3850 2180 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 5310 -3310 5480 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 -\\""}
B 2 5290 -3530 5460 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v1 vb2 @m.xm21.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4940 -3530 5110 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm23.msky130_fd_pr__pfet_01v8[vth] @m.xm21.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 4940 -3740 5110 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v1 - \\""}
B 2 5200 -3670 5370 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 @m.xm23.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 6100 -3530 6270 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 -\\""}
B 2 5680 -3520 5850 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm24.msky130_fd_pr__pfet_01v8[vth] @m.xm22.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 5680 -3690 5850 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v2 -\\""}
B 2 6100 -3680 6270 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 @m.xm24.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4930 -3310 5100 -3210 {flags=graph
y1=0.948
y2=0.958
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 6100 -3290 6270 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 @m.xm22.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 5710 -3290 5880 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 - \\""}
B 2 5420 -3850 5590 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 7450 -3820 7980 -3440 {flags=graph

y2=0.88
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.72



color="5 17"
node="x
y"}
B 2 1880 -3100 2410 -2720 {flags=graph

y2=0.88
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.72



color="5 17"
node="x
y"}
B 2 8070 -2170 8240 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm20.msky130_fd_pr__nfet_01v8[vth] @m.xm19.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 7690 -2020 7860 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vs20 v_p - \\""}
B 2 7500 -2020 7670 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p -\\""}
B 2 7880 -2020 8050 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p @m.xm19.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7690 -2170 7860 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vs20 - \\""}
B 2 7500 -2170 7670 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 -\\""}
B 2 7880 -2170 8050 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 @m.xm20.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7500 -2340 7670 -2240 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=6.6544831e-07
x2=1.6484883e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"y vd2 @m.xm10.msky130_fd_pr__nfet_01v8[vth] + -\\""}
T {VDS3} 3140 -3710 0 0 0.3 0.3 {}
T {VGS3-VTH3} 3640 -3640 0 0 0.3 0.3 {}
T {VTH3-VTH1} 3080 -3490 0 0 0.3 0.3 {}
T {VGS1-VTH1} 3590 -3430 0 0 0.3 0.3 {}
T {VDS1} 3130 -3270 0 0 0.3 0.3 {}
T {VDS4} 3880 -3650 0 0 0.3 0.3 {}
T {VGS4-VTH4} 4550 -3650 0 0 0.3 0.3 {}
T {VTH4-VTH2} 3820 -3480 0 0 0.3 0.3 {}
T {VGS2-VTH2} 4540 -3250 0 0 0.3 0.3 {}
T {VDS2} 4030 -3190 0 0 0.3 0.3 {}
T {Vb2} 3640 -3180 0 0 0.3 0.3 {}
T {Vb5} 4540 -3480 0 0 0.3 0.3 {}
T {VGS5-VTH5} 1920 -3530 0 0 0.3 0.3 {}
T {VDS6} 1460 -3370 0 0 0.3 0.3 {}
T {VDS43} 2210 -3650 0 0 0.3 0.3 {}
T {VGS43-VTH43} 2880 -3650 0 0 0.3 0.3 {}
T {VTH43-VTH6} 2150 -3480 0 0 0.3 0.3 {}
T {VGS6-VTH6} 2870 -3250 0 0 0.3 0.3 {}
T {VDS2} 2360 -3190 0 0 0.3 0.3 {}
T {Vb6} 1970 -3280 0 0 0.3 0.3 {}
T {Vb7} 2870 -3480 0 0 0.3 0.3 {}
T {VDS23} 4880 -3710 0 0 0.3 0.3 {}
T {VGS23-VTH23} 5380 -3640 0 0 0.3 0.3 {}
T {VTH23-VTH21} 4820 -3490 0 0 0.3 0.3 {}
T {VGS21-VTH21} 5330 -3430 0 0 0.3 0.3 {}
T {VDS21} 4870 -3270 0 0 0.3 0.3 {}
T {VDS24} 5620 -3650 0 0 0.3 0.3 {}
T {VGS24-VTH24} 6290 -3650 0 0 0.3 0.3 {}
T {VTH24-VTH22} 5560 -3480 0 0 0.3 0.3 {}
T {VGS22-VTH22} 6280 -3250 0 0 0.3 0.3 {}
T {VDS2} 5770 -3190 0 0 0.3 0.3 {}
T {Vb2} 5380 -3180 0 0 0.3 0.3 {}
T {Vb3} 6280 -3480 0 0 0.3 0.3 {}
T {VTH20-VTH19} 8100 -2070 0 0 0.3 0.3 {}
T {VDS19} 7750 -1920 0 0 0.3 0.3 {}
T {VGS19} 7560 -1920 0 0 0.3 0.3 {}
T {VGS19-VTH19} 7910 -1920 0 0 0.3 0.3 {}
T {VDS20} 7750 -2070 0 0 0.3 0.3 {}
T {VGS20} 7560 -2070 0 0 0.3 0.3 {}
T {VGS20-VTH20} 7910 -2070 0 0 0.3 0.3 {}
T {VGS10-VTH10} 7540 -2230 0 0 0.3 0.3 {}
N 6660 -1770 6660 -1680 {lab=V_p}
N 6660 -1680 7410 -1680 {lab=V_p}
N 7410 -1770 7410 -1680 {lab=V_p}
N 6660 -2380 6660 -1830 {lab=VD1}
N 7410 -2380 7410 -1830 {lab=VD2}
N 6700 -2410 7370 -2410 {lab=Vb1}
N 6660 -2740 6660 -2440 {lab=X}
N 7410 -2740 7410 -2440 {lab=Y}
N 6660 -3160 6660 -2800 {lab=VD7}
N 7410 -3160 7410 -2800 {lab=VD6}
N 6700 -2770 7370 -2770 {lab=Vb4}
N 7410 -2770 7480 -2770 {lab=VD6}
N 7480 -2840 7480 -2770 {lab=VD6}
N 7410 -2840 7480 -2840 {lab=VD6}
N 6590 -2770 6660 -2770 {lab=VD7}
N 6590 -2840 6590 -2770 {lab=VD7}
N 6590 -2840 6660 -2840 {lab=VD7}
N 6660 -3340 6660 -3220 {lab=VDD}
N 7410 -3340 7410 -3220 {lab=VDD}
N 6700 -3190 7370 -3190 {lab=Vb5}
N 7410 -3190 7480 -3190 {lab=VDD}
N 7480 -3260 7480 -3190 {lab=VDD}
N 7410 -3260 7480 -3260 {lab=VDD}
N 6590 -3190 6660 -3190 {lab=VDD}
N 6590 -3260 6590 -3190 {lab=VDD}
N 6590 -3260 6660 -3260 {lab=VDD}
N 6660 -3340 7410 -3340 {lab=VDD}
N 6610 -2410 6660 -2410 {lab=GND}
N 6610 -2410 6610 -2350 {lab=GND}
N 6610 -2350 7470 -2350 {lab=GND}
N 7470 -2410 7470 -2350 {lab=GND}
N 7410 -2410 7470 -2410 {lab=GND}
N 6840 -3400 6840 -3340 {lab=VDD}
N 7110 -1800 7410 -1800 {lab=GND}
N 6660 -1800 7110 -1800 {lab=GND}
N 6960 -1680 6960 -1570 {lab=V_p}
N 7110 -1800 7110 -1540 {lab=GND}
N 6960 -1540 7110 -1540 {lab=GND}
N 6960 -1510 6960 -1420 {lab=GND}
N 6960 -1460 7110 -1460 {lab=GND}
N 7110 -1540 7110 -1460 {lab=GND}
N 7450 -1800 7540 -1800 {lab=opamp_Vin+}
N 5060 -1680 5060 -1570 {lab=V_p_mir}
N 4980 -1540 5060 -1540 {lab=GND}
N 5060 -1510 5060 -1420 {lab=GND}
N 4980 -1460 5060 -1460 {lab=GND}
N 4980 -1540 4980 -1460 {lab=GND}
N 5100 -1540 6920 -1540 {lab=VGS9}
N 5060 -2460 5060 -2400 {lab=VDD}
N 5140 -1800 5230 -1800 {lab=GND}
N 4900 -1800 5140 -1800 {lab=GND}
N 4900 -1770 4900 -1680 {lab=V_p_mir}
N 4900 -1680 5230 -1680 {lab=V_p_mir}
N 5230 -1770 5230 -1680 {lab=V_p_mir}
N 4980 -1800 4980 -1540 {lab=GND}
N 4900 -1950 4900 -1830 {lab=VGS9}
N 4900 -1950 5230 -1950 {lab=VGS9}
N 5230 -1950 5230 -1830 {lab=VGS9}
N 5060 -2150 5060 -1950 {lab=VGS9}
N 5270 -1800 5340 -1800 {lab=opamp_Vin-}
N 4790 -1800 4860 -1800 {lab=opamp_Vin+}
N 5060 -2070 5460 -2070 {lab=VGS9}
N 5460 -2070 5460 -1540 {lab=VGS9}
N 6960 -2060 6960 -1980 {lab=Vb1}
N 6960 -1950 7110 -1950 {lab=GND}
N 6960 -1920 6960 -1680 {lab=V_p}
N 6960 -2410 6960 -2120 {lab=Vb1}
N 6830 -1950 6920 -1950 {lab=Vb1}
N 6830 -2210 6830 -1950 {lab=Vb1}
N 6830 -2210 6960 -2210 {lab=Vb1}
N 6960 -2980 6960 -2410 {lab=Vb1}
N 6960 -3340 6960 -3040 {lab=VDD}
N 5150 -3320 5150 -3200 {lab=Vb2}
N 5930 -3320 5930 -3200 {lab=Vb3}
N 5150 -3530 5150 -3380 {lab=V1}
N 5930 -3530 5930 -3380 {lab=V2}
N 5860 -3350 5930 -3350 {lab=V2}
N 5860 -3420 5860 -3350 {lab=V2}
N 5860 -3420 5930 -3420 {lab=V2}
N 5080 -3350 5150 -3350 {lab=V1}
N 5080 -3420 5080 -3350 {lab=V1}
N 5080 -3420 5150 -3420 {lab=V1}
N 5150 -3710 5150 -3590 {lab=VDD}
N 5930 -3710 5930 -3590 {lab=VDD}
N 5860 -3560 5930 -3560 {lab=VDD}
N 5860 -3630 5860 -3560 {lab=VDD}
N 5860 -3630 5930 -3630 {lab=VDD}
N 5080 -3560 5150 -3560 {lab=VDD}
N 5080 -3630 5080 -3560 {lab=VDD}
N 5080 -3630 5150 -3630 {lab=VDD}
N 5350 -3770 5350 -3710 {lab=VDD}
N 5150 -3710 5930 -3710 {lab=VDD}
N 5190 -3560 5270 -3560 {lab=Vb2}
N 5190 -3350 5270 -3350 {lab=Vb2}
N 5970 -3560 6050 -3560 {lab=Vb3}
N 6050 -3560 6050 -3250 {lab=Vb3}
N 5930 -3250 6050 -3250 {lab=Vb3}
N 5270 -3560 5270 -3250 {lab=Vb2}
N 5150 -3250 5270 -3250 {lab=Vb2}
N 5970 -3350 6130 -3350 {lab=Vb2}
N 10440 -2230 10440 -2180 {lab=VDD}
N 10440 -2020 10440 -1960 {lab=GND}
N 10440 -2120 10440 -2080 {lab=#net1}
N 10440 -2460 10440 -2410 {lab=GND}
N 10440 -2570 10440 -2520 {lab=#net2}
N 10320 -2490 10320 -2150 {lab=X}
N 11070 -2490 11140 -2490 {lab=Y}
N 11140 -2490 11140 -2150 {lab=Y}
N 11070 -2150 11140 -2150 {lab=Y}
N 10200 -2330 10320 -2330 {lab=X}
N 11140 -2330 11260 -2330 {lab=Y}
N 10880 -2540 11030 -2540 {lab=V_1}
N 10880 -2100 11030 -2100 {lab=V_2}
N 10440 -2490 10520 -2490 {lab=VDD}
N 10440 -2650 10520 -2650 {lab=VDD}
N 10440 -2680 10440 -2620 {lab=VDD}
N 10520 -2650 10520 -2490 {lab=VDD}
N 10440 -1990 10520 -1990 {lab=GND}
N 10440 -2150 10520 -2150 {lab=GND}
N 10520 -2150 10520 -1990 {lab=GND}
N 11030 -2230 11030 -2180 {lab=VDD}
N 11030 -2020 11030 -1960 {lab=GND}
N 11030 -2120 11030 -2080 {lab=V_2}
N 11030 -2460 11030 -2410 {lab=GND}
N 11030 -2570 11030 -2520 {lab=V_1}
N 10950 -2490 11030 -2490 {lab=VDD}
N 10950 -2650 11030 -2650 {lab=VDD}
N 11030 -2680 11030 -2620 {lab=VDD}
N 10950 -2650 10950 -2490 {lab=VDD}
N 10950 -1990 11030 -1990 {lab=GND}
N 10950 -2150 11030 -2150 {lab=GND}
N 10950 -2150 10950 -1990 {lab=GND}
N 10740 -2540 10740 -2100 {lab=V_tot}
N 9410 -1730 9410 -1660 {lab=V_err_p}
N 9170 -1730 9410 -1730 {lab=V_err_p}
N 9170 -1730 9170 -1660 {lab=V_err_p}
N 9290 -1780 9290 -1730 {lab=V_err_p}
N 9290 -1890 9290 -1840 {lab=VDD}
N 9410 -1600 9410 -1480 {lab=err_opamp_mir}
N 9170 -1600 9170 -1480 {lab=err_opamp_out}
N 9410 -1420 9410 -1370 {lab=GND}
N 9170 -1370 9410 -1370 {lab=GND}
N 9170 -1420 9170 -1370 {lab=GND}
N 9290 -1370 9290 -1320 {lab=GND}
N 9170 -1630 9410 -1630 {lab=VDD}
N 9210 -1450 9370 -1450 {lab=err_opamp_mir}
N 9130 -1450 9170 -1450 {lab=GND}
N 9130 -1450 9130 -1400 {lab=GND}
N 9130 -1400 9170 -1400 {lab=GND}
N 9410 -1450 9450 -1450 {lab=GND}
N 9450 -1450 9450 -1400 {lab=GND}
N 9410 -1400 9450 -1400 {lab=GND}
N 9310 -1530 9410 -1530 {lab=err_opamp_mir}
N 9310 -1530 9310 -1450 {lab=err_opamp_mir}
N 10740 -2100 10740 -1630 {lab=V_tot}
N 9040 -1630 9130 -1630 {lab=V_ref}
N 7110 -1540 7260 -1540 {lab=GND}
N 7110 -1460 7260 -1460 {lab=GND}
N 7260 -1510 7260 -1460 {lab=GND}
N 7260 -1680 7260 -1570 {lab=V_p}
N 9450 -1630 10740 -1630 {lab=V_tot}
N 11280 -1870 11280 -1810 {lab=V_ref}
N 9290 -1810 9330 -1810 {lab=VDD}
N 9330 -1870 9330 -1810 {lab=VDD}
N 9290 -1870 9330 -1870 {lab=VDD}
N 9330 -1810 9330 -1630 {lab=VDD}
N 8330 -1730 8330 -1660 {lab=V_err_mir_p}
N 8330 -1730 8570 -1730 {lab=V_err_mir_p}
N 8570 -1730 8570 -1660 {lab=V_err_mir_p}
N 8450 -1780 8450 -1730 {lab=V_err_mir_p}
N 8450 -1890 8450 -1840 {lab=VDD}
N 8330 -1630 8570 -1630 {lab=VDD}
N 8610 -1630 8700 -1630 {lab=V_ref}
N 8410 -1810 8450 -1810 {lab=VDD}
N 8410 -1870 8410 -1810 {lab=VDD}
N 8410 -1870 8450 -1870 {lab=VDD}
N 8410 -1810 8410 -1630 {lab=VDD}
N 8490 -1810 9250 -1810 {lab=V_gate}
N 8330 -1600 8330 -1540 {lab=V_gate}
N 8330 -1540 8570 -1540 {lab=V_gate}
N 8570 -1600 8570 -1540 {lab=V_gate}
N 8450 -1540 8450 -1420 {lab=V_gate}
N 8200 -1630 8290 -1630 {lab=V_tot}
N 8450 -1360 8450 -1310 {lab=GND}
N 8890 -1810 8890 -1480 {lab=V_gate}
N 8450 -1480 8890 -1480 {lab=V_gate}
N 7300 -1540 8000 -1540 {lab=err_opamp_out}
N 8000 -1540 8000 -1180 {lab=err_opamp_out}
N 8000 -1180 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9170 -1550 {lab=err_opamp_out}
N 7110 -2090 7110 -1800 {lab=GND}
N 7110 -2350 7110 -2090 {lab=GND}
N 8140 -3190 8140 -2890 {lab=V_OUT_X}
N 8900 -3190 8900 -2890 {lab=V_OUT_Y}
N 8900 -3220 8970 -3220 {lab=VDD}
N 8970 -3290 8970 -3220 {lab=VDD}
N 8900 -3290 8970 -3290 {lab=VDD}
N 8070 -3220 8140 -3220 {lab=VDD}
N 8070 -3290 8140 -3290 {lab=VDD}
N 8070 -3290 8070 -3220 {lab=VDD}
N 8140 -3320 8140 -3250 {lab=VDD}
N 8900 -3320 8900 -3250 {lab=VDD}
N 8140 -2830 8140 -2660 {lab=GND}
N 8900 -2830 8900 -2660 {lab=GND}
N 8900 -2790 8970 -2790 {lab=GND}
N 8970 -2860 8970 -2790 {lab=GND}
N 8900 -2860 8970 -2860 {lab=GND}
N 8070 -2790 8140 -2790 {lab=GND}
N 8070 -2860 8140 -2860 {lab=GND}
N 8070 -2860 8070 -2790 {lab=GND}
N 8180 -3220 8290 -3220 {lab=X}
N 8750 -3220 8860 -3220 {lab=Y}
N 8030 -3050 8140 -3050 {lab=V_OUT_X}
N 8900 -3050 9010 -3050 {lab=V_OUT_Y}
N 8140 -3320 8900 -3320 {lab=VDD}
N 8140 -2660 8900 -2660 {lab=GND}
N 8520 -3380 8520 -3320 {lab=VDD}
N 8520 -2660 8520 -2600 {lab=GND}
N 8520 -2860 8520 -2790 {lab=V_b}
N 8520 -2730 8520 -2660 {lab=GND}
N 8770 -2980 8900 -2980 {lab=V_OUT_Y}
N 8520 -2860 8860 -2860 {lab=V_b}
N 8580 -2980 8710 -2980 {lab=V_b}
N 8580 -2980 8580 -2860 {lab=V_b}
N 8140 -2980 8270 -2980 {lab=V_OUT_X}
N 8330 -2980 8460 -2980 {lab=V_b}
N 8180 -2860 8520 -2860 {lab=V_b}
N 8460 -2980 8460 -2860 {lab=V_b}
N 10650 -2100 10820 -2100 {lab=V_tot}
N 10650 -2540 10820 -2540 {lab=V_tot}
N 10440 -2540 10590 -2540 {lab=#net2}
N 10440 -2100 10590 -2100 {lab=#net1}
N 10320 -2490 10400 -2490 {lab=X}
N 10320 -2150 10400 -2150 {lab=X}
N 6490 -1800 6620 -1800 {lab=opamp_Vin-}
N 11030 -2100 11150 -2100 {lab=V_2}
N 11030 -2540 11120 -2540 {lab=V_1}
N 6660 -1680 7410 -1680 {lab=V_p}
N 6140 -1800 6490 -1800 {lab=opamp_Vin-}
N 5340 -1800 6140 -1800 {lab=opamp_Vin-}
N 4790 -1900 6140 -1900 {lab=opamp_Vin+}
N 4790 -1900 4790 -1800 {lab=opamp_Vin+}
N 7540 -1900 7540 -1800 {lab=opamp_Vin+}
N 6140 -1900 7540 -1900 {lab=opamp_Vin+}
N 6490 -1740 6490 -1670 {lab=opamp_Vin-}
N 7540 -1740 7540 -1670 {lab=opamp_Vin+}
N 5060 -2340 5060 -2150 {lab=VGS9}
N 6490 -1800 6490 -1740 {lab=opamp_Vin-}
N 7540 -1800 7540 -1740 {lab=opamp_Vin+}
N 3420 -3320 3420 -3200 {lab=Vb4}
N 4200 -3320 4200 -3200 {lab=Vb5}
N 3420 -3530 3420 -3380 {lab=V3}
N 4200 -3530 4200 -3380 {lab=V4}
N 4130 -3350 4200 -3350 {lab=V4}
N 4130 -3420 4130 -3350 {lab=V4}
N 4130 -3420 4200 -3420 {lab=V4}
N 3350 -3350 3420 -3350 {lab=V3}
N 3350 -3420 3350 -3350 {lab=V3}
N 3350 -3420 3420 -3420 {lab=V3}
N 3420 -3710 3420 -3590 {lab=VDD}
N 4200 -3710 4200 -3590 {lab=VDD}
N 4130 -3560 4200 -3560 {lab=VDD}
N 4130 -3630 4130 -3560 {lab=VDD}
N 4130 -3630 4200 -3630 {lab=VDD}
N 3350 -3560 3420 -3560 {lab=VDD}
N 3350 -3630 3350 -3560 {lab=VDD}
N 3350 -3630 3420 -3630 {lab=VDD}
N 3620 -3770 3620 -3710 {lab=VDD}
N 3420 -3710 4200 -3710 {lab=VDD}
N 3460 -3560 3540 -3560 {lab=Vb4}
N 3460 -3350 3540 -3350 {lab=Vb4}
N 4240 -3560 4320 -3560 {lab=Vb5}
N 4320 -3560 4320 -3250 {lab=Vb5}
N 4200 -3250 4320 -3250 {lab=Vb5}
N 3540 -3560 3540 -3250 {lab=Vb4}
N 3420 -3250 3540 -3250 {lab=Vb4}
N 4240 -3350 4400 -3350 {lab=Vb4}
N 1750 -3420 1750 -3210 {lab=Vb6}
N 2530 -3320 2530 -3200 {lab=Vb7}
N 2530 -3530 2530 -3380 {lab=V5}
N 2460 -3350 2530 -3350 {lab=V5}
N 2460 -3420 2460 -3350 {lab=V5}
N 2460 -3420 2530 -3420 {lab=V5}
N 1680 -3450 1750 -3450 {lab=VDD}
N 1680 -3520 1680 -3450 {lab=VDD}
N 1680 -3520 1750 -3520 {lab=VDD}
N 2530 -3710 2530 -3590 {lab=VDD}
N 2460 -3560 2530 -3560 {lab=VDD}
N 2460 -3630 2460 -3560 {lab=VDD}
N 2460 -3630 2530 -3630 {lab=VDD}
N 1950 -3770 1950 -3710 {lab=VDD}
N 1750 -3710 2530 -3710 {lab=VDD}
N 1790 -3450 1870 -3450 {lab=Vb6}
N 2570 -3560 2650 -3560 {lab=Vb7}
N 2650 -3560 2650 -3250 {lab=Vb7}
N 2530 -3250 2650 -3250 {lab=Vb7}
N 1750 -3350 1870 -3350 {lab=Vb6}
N 2570 -3350 2730 -3350 {lab=Vb6}
N 1870 -3450 1870 -3350 {lab=Vb6}
N 1750 -3710 1750 -3480 {lab=VDD}
N 6960 -2120 6960 -2060 {lab=Vb1}
C {devices/vsource.sym} 680 -3000 0 0 {name=VDD value=1.8 savecurrent=false
* "pwl(0 0 1us 0 2us 1.8)"}
C {devices/gnd.sym} 680 -2970 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 680 -3030 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 470 -3050 0 0 {name=CORNER only_toplevel=false corner=tt}
C {sky130_fd_pr/nfet_01v8.sym} 6640 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7430 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6680 -2410 0 1 {name=M9
W=32
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7390 -2410 0 0 {name=M10
W=32
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 6840 -3400 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 6830 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb5}
C {lab_wire.sym} 6830 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb4}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1540 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 6960 -1420 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 6490 -1610 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5080 -1540 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 5060 -1420 0 0 {name=l14 lab=GND}
C {isource.sym} 5060 -2370 0 0 {name=I0 value=100u}
C {vdd.sym} 5060 -2460 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 4880 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5250 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1950 0 0 {name=M19
W=1
L=3.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {isource.sym} 6960 -3010 0 0 {name=I1 value=10u}
C {lab_pin.sym} 6660 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3350 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3350 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3560 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3560 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 5350 -3770 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 6050 -3560 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 5270 -3350 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 6130 -3350 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {isource.sym} 5150 -3170 0 0 {name=I2 value=50u}
C {gnd.sym} 5150 -3140 0 1 {name=l17 lab=GND}
C {isource.sym} 5930 -3170 0 0 {name=I3 value=50u}
C {gnd.sym} 5930 -3140 0 1 {name=l18 lab=GND}
C {lab_pin.sym} 7410 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 10420 -2150 0 0 {name=M25
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10420 -2490 0 0 {name=M26
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 10440 -2050 0 0 {name=I4 value=20u}
C {vdd.sym} 10440 -2230 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 10440 -1960 0 0 {name=l20 lab=GND}
C {isource.sym} 10440 -2590 0 0 {name=I5 value=20u}
C {vdd.sym} 10440 -2680 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 10440 -2410 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 10200 -2330 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 11260 -2330 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2540 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2560 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2100 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2080 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2540 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 10850 -2560 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2100 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10850 -2080 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 10740 -2330 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 11050 -2150 0 1 {name=M27
W=2.5
L=0.3
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11050 -2490 0 1 {name=M28
W=5
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 11030 -2050 0 1 {name=I6 value=20u}
C {vdd.sym} 11030 -2230 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 11030 -1960 0 1 {name=l28 lab=GND}
C {isource.sym} 11030 -2590 0 1 {name=I7 value=20u}
C {vdd.sym} 11030 -2680 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 11030 -2410 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 9430 -1630 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -1630 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {isource.sym} 8450 -1390 0 0 {name=I8 value=20u}
C {vdd.sym} 9290 -1890 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 9390 -1450 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9190 -1450 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9290 -1320 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 9040 -1630 0 0 {name=p28 sig_type=std_logic lab=V_ref}
C {devices/vsource.sym} 11280 -1780 0 1 {name=VDD1 value=0.9 savecurrent=false
}
C {devices/gnd.sym} 11280 -1750 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 11280 -1870 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 9530 -1630 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 9270 -1810 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8310 -1630 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8590 -1630 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 8450 -1890 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 8700 -1630 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 8200 -1630 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8470 -1810 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8450 -1310 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 7540 -1610 0 0 {name=l36 lab=GND}
C {devices/vsource.sym} 6490 -1640 0 1 {name=V2 value="sin(1.24 -0.001 1Meg)" savecurrent=false
* 1.24
* }
C {devices/vsource.sym} 7540 -1640 0 0 {name=V1 value="sin(1.24 0.001 1Meg)" savecurrent=false
* "1.24 AC 1"
* 1.24
* 0.001 }
C {sky130_fd_pr/nfet_01v8.sym} 8160 -2860 0 1 {name=M37
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8880 -2860 0 0 {name=M38
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8160 -3220 0 1 {name=M39
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8880 -3220 0 0 {name=M40
W=28
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8290 -3220 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 8750 -3220 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 8030 -3050 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 9010 -3050 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 8520 -3380 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 8520 -2600 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8300 -2980 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8300 -2960 0 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8740 -2980 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8740 -2960 0 1 {name=l40 lab=GND}
C {isource.sym} 8520 -2760 0 0 {name=I9 value=2u}
C {sky130_fd_pr/nfet_01v8.sym} 7280 -1540 0 1 {name=M41
W=10
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7540 -1690 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 6490 -1690 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {simulator_commands_shown.sym} -170 -3140 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm1.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm1.msky130_fd_pr__pfet_01v8[vds]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[vgs]
+@m.xm2.msky130_fd_pr__pfet_01v8[vds]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm3.msky130_fd_pr__pfet_01v8[vth]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[vth]
+@m.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.xm5.msky130_fd_pr__pfet_01v8[vth]
+@m.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__pfet_01v8[gm]
+@m.xm10.msky130_fd_pr__pfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gm]
+@m.xm11.msky130_fd_pr__pfet_01v8[vth]
+@m.xm12.msky130_fd_pr__pfet_01v8[gm]
+@m.xm12.msky130_fd_pr__pfet_01v8[vth]
+@m.xm13.msky130_fd_pr__pfet_01v8[gm]
+@m.xm13.msky130_fd_pr__pfet_01v8[vth]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__nfet_01v8[gm]
+@m.xm15.msky130_fd_pr__nfet_01v8[vth]
+@m.xm16.msky130_fd_pr__nfet_01v8[gm]
+@m.xm16.msky130_fd_pr__nfet_01v8[vth]
+@m.xm17.msky130_fd_pr__nfet_01v8[gm]
+@m.xm17.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__pfet_01v8[gm]
+@m.xm21.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[gm]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[gm]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]
+@m.xm36.msky130_fd_pr__pfet_01v8[gm]
+@m.xm36.msky130_fd_pr__pfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm39.msky130_fd_pr__pfet_01v8[gm]
+@m.xm39.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm41.msky130_fd_pr__nfet_01v8[gm]
+@m.xm41.msky130_fd_pr__nfet_01v8[vth]
+@m.xm42.msky130_fd_pr__nfet_01v8[gm]
+@m.xm42.msky130_fd_pr__nfet_01v8[vth]
+@m.xm43.msky130_fd_pr__pfet_01v8[gm]
+@m.xm43.msky130_fd_pr__pfet_01v8[vth]

.ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.238 1.242 0.0001
  * dc VDD 0 1.8 0.9
  * dc temp -40 120 10 VDD 0 4.0 0.2
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  tran 1n 3u
  * tran 1ns 10us
  * ac dec 20 1 1T
  remzerovec
  write tb_opamp_cur_mir_test.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc


"}
C {lab_wire.sym} 6960 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 6660 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 7410 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 6830 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6390 -1540 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 5060 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 6660 -3000 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 7410 -3000 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 5150 -3470 0 1 {name=p29 sig_type=std_logic lab=V1}
C {lab_pin.sym} 5930 -3470 0 1 {name=p30 sig_type=std_logic lab=V2}
C {lab_pin.sym} 9410 -1550 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 9250 -1730 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 8490 -1730 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 8940 -1810 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 9020 -1460 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 11150 -2100 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 11120 -2540 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 8520 -2860 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 6830 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3350 0 1 {name=M1
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3350 0 1 {name=M2
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3560 0 1 {name=M3
W=0.81
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3560 0 1 {name=M4
W=3.1
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3620 -3770 0 0 {name=l1 lab=VDD}
C {lab_pin.sym} 4320 -3560 0 1 {name=p1 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 3540 -3350 0 1 {name=p2 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 4400 -3350 0 1 {name=p3 sig_type=std_logic lab=Vb4}
C {isource.sym} 3420 -3170 0 0 {name=I10 value=50u}
C {gnd.sym} 3420 -3140 0 1 {name=l2 lab=GND}
C {isource.sym} 4200 -3170 0 0 {name=I11 value=50u}
C {gnd.sym} 4200 -3140 0 1 {name=l5 lab=GND}
C {lab_pin.sym} 3420 -3470 0 1 {name=p4 sig_type=std_logic lab=V3}
C {lab_pin.sym} 4200 -3470 0 1 {name=p5 sig_type=std_logic lab=V4}
C {devices/ngspice_get_value.sym} 3310 -3560 0 1 {name=r5 node=v(@m.xm3.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3310 -3390 0 1 {name=r6 node=v(@m.xm1.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3550 0 1 {name=r3 node=v(@m.xm4.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3380 0 1 {name=r4 node=v(@m.xm2.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -3450 0 1 {name=M5
W=0.59
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3350 0 1 {name=M6
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3560 0 1 {name=M43
W=3.1
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 1950 -3770 0 0 {name=l6 lab=VDD}
C {lab_pin.sym} 2650 -3560 0 1 {name=p6 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 1870 -3450 0 1 {name=p7 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2730 -3350 0 1 {name=p8 sig_type=std_logic lab=Vb6}
C {isource.sym} 1750 -3180 0 0 {name=I12 value=50u}
C {gnd.sym} 1750 -3150 0 1 {name=l7 lab=GND}
C {isource.sym} 2530 -3170 0 0 {name=I13 value=50u}
C {gnd.sym} 2530 -3140 0 1 {name=l8 lab=GND}
C {lab_pin.sym} 2530 -3470 0 1 {name=p12 sig_type=std_logic lab=V5}
C {devices/ngspice_get_value.sym} 1640 -3490 0 1 {name=r2 node=v(@m.xm5.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3550 0 1 {name=r7 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3380 0 1 {name=r8 node=v(@m.xm6.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 6820 -3760 0 1 {name=p11 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 6900 -3550 0 1 {name=p49 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 7040 -3760 0 1 {name=p50 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 7120 -3550 0 1 {name=p51 sig_type=std_logic lab=Vb4}
C {devices/ngspice_get_value.sym} 5050 -3560 0 1 {name=r1 node=v(@m.xm23.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5050 -3390 0 1 {name=r9 node=v(@m.xm21.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3550 0 1 {name=r14 node=v(@m.xm24.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3380 0 1 {name=r15 node=v(@m.xm22.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 7250 -3760 0 1 {name=p54 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 7330 -3550 0 1 {name=p55 sig_type=std_logic lab=Vb2}
C {devices/ngspice_get_value.sym} 6930 -1890 2 0 {name=r17 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6710 -3150 2 1 {name=r16 node=v(@m.xm13.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
