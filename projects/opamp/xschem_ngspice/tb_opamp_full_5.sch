v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 5790 -810 6400 -260 {flags=graph

y2=73
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.009



color="5 17"
node="x
y"}
B 2 6490 -810 7100 -260 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.4




color="12 17"
node="v_out_x
v_out_y"}
B 2 6220 -1480 6830 -930 {flags=graph

y2=1.2418669
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=1.2383484





color="6 7"
node="opamp_vin+
opamp_vin-"}
B 2 5790 -190 6400 360 {flags=graph

y2=0.15
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.15



color=7
node="\\"x y -\\""}
B 2 6490 -190 7100 360 {flags=graph

y2=0.97
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.97



color=6
node="\\"v_out_x v_out_y -\\""}
B 2 5550 -2240 5900 -1980 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=1.2





color=6
node=opamp_vin-}
B 2 3570 -3310 3740 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 -\\""}
B 2 3550 -3530 3720 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 @m.xm1.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3200 -3530 3370 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm3.msky130_fd_pr__pfet_01v8[vth] @m.xm1.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3200 -3740 3370 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v3 -\\""}
B 2 3460 -3670 3630 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 @m.xm3.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4360 -3530 4530 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 -\\""}
B 2 3940 -3520 4110 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm4.msky130_fd_pr__pfet_01v8[vth] @m.xm2.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3940 -3690 4110 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v4 -\\""}
B 2 4360 -3680 4530 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 @m.xm4.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3190 -3310 3360 -3210 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 4360 -3290 4530 -3200 {flags=graph
y1=0.876
y2=0.896
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb4 @m.xm2.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3970 -3290 4140 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb5 - \\""}
B 2 3680 -3850 3850 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 1900 -3410 2070 -3290 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 -\\""}
B 2 1880 -3630 2050 -3540 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 @m.xm5.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2690 -3530 2860 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 -\\""}
B 2 2270 -3520 2440 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm43.msky130_fd_pr__pfet_01v8[vth] @m.xm7.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 2270 -3690 2440 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v5 -\\""}
B 2 2690 -3680 2860 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 @m.xm43.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 1520 -3410 1690 -3310 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 - \\""}
B 2 2690 -3290 2860 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb6 @m.xm6.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2300 -3290 2470 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb7 - \\""}
B 2 2010 -3850 2180 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 5310 -3310 5480 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 -\\""}
B 2 5290 -3530 5460 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v1 vb2 @m.xm21.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4940 -3530 5110 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm23.msky130_fd_pr__pfet_01v8[vth] @m.xm21.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 4940 -3740 5110 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v1 - \\""}
B 2 5200 -3670 5370 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 @m.xm23.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 6100 -3530 6270 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 -\\""}
B 2 5680 -3520 5850 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm24.msky130_fd_pr__pfet_01v8[vth] @m.xm22.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 5680 -3690 5850 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v2 -\\""}
B 2 6100 -3680 6270 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 @m.xm24.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4930 -3310 5100 -3210 {flags=graph
y1=0.948
y2=0.958
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 6100 -3290 6270 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 @m.xm22.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 5710 -3290 5880 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 - \\""}
B 2 5420 -3850 5590 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 2460 -2920 2990 -2540 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.44



color="5 17"
node="x
y"}
B 2 8070 -2170 8240 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm20.msky130_fd_pr__nfet_01v8[vth] @m.xm19.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 7690 -2020 7860 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vs20 v_p - \\""}
B 2 7500 -2020 7670 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p -\\""}
B 2 7880 -2020 8050 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p @m.xm19.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7690 -2170 7860 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vs20 - \\""}
B 2 7500 -2170 7670 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 -\\""}
B 2 7880 -2170 8050 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 @m.xm20.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7500 -2340 7670 -2240 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"y vd2 @m.xm10.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 12260 -2520 12790 -2140 {flags=graph

y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.00047




color="6 7 11"
node="y
\\"v_1 y - y v_2 - - 2 /\\"
\\"v_tot\\""}
B 2 11670 -2950 12200 -2570 {flags=graph

y2=0.66
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.59




color=6
node="\\"v_1 y -\\""}
B 2 11670 -2090 12200 -1710 {flags=graph

y2=0.95
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.94





color=6
node=v_tot}
B 2 6300 -3090 6590 -2910 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.9



color="5 17"
node="x
y"}
B 2 6240 -2720 6410 -2600 {flags=graph
y1=1.17
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 vb4 -\\""
y2=1.2}
B 2 6050 -2720 6220 -2600 {flags=graph
y1=0.3
y2=0.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 x -\\""}
B 2 6430 -2720 6620 -2600 {flags=graph
y1=0.29
y2=0.31
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 vb4 @m.xm11.msky130_fd_pr__pfet_01v8[vth] + -\\""}
B 2 6240 -2340 6410 -2190 {flags=graph
y1=0.97
y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vd1 -\\""}
B 2 6050 -2340 6220 -2190 {flags=graph
y1=0.23218228
y2=0.39346228
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"x vd1 - \\""}
B 2 6430 -2340 6600 -2190 {flags=graph
y1=0.16
y2=0.18
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 @m.xm9.msky130_fd_pr__nfet_01v8[vth] - vd1 -\\""}
B 2 6240 -2100 6410 -1950 {flags=graph
y1=0.94516091
y2=0.94843771
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"opamp_vin- v_p -\\""}
B 2 6050 -2100 6220 -1950 {flags=graph
y1=0.3
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vd1 v_p - \\""}
B 2 6430 -2100 6600 -1950 {flags=graph
y1=0.16
y2=0.18
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"opamp_vin- @m.xm7.msky130_fd_pr__nfet_01v8[vth] - v_p -\\""}
B 2 6050 -2530 6220 -2390 {flags=graph
y1=0.52
y2=0.54
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vd1}
B 2 1460 -1920 1830 -1670 {flags=graph

y2=1.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0





color=4
node=i(@m.xm59.msky130_fd_pr__pfet_01v8[id])}
B 2 1820 -2920 2190 -2670 {flags=graph

y2=5.5e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0





color=7
node=i(@m.xm44.msky130_fd_pr__nfet_01v8[id])}
B 2 12850 -2520 13380 -2140 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.67




color="6 7 11 17 9"
node="\\"v_1 y -\\"
\\"y v_2 -\\"
y
\\"y v_1 -\\"


\\"v_1 y - y v_2 - +\\""}
B 2 9800 -2330 10120 -2120 {flags=graph

y2=-2.3e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-3e-06






color="7 6"
node="i(@r.xr11.x0.rend1[i])
i(@r.xr11.x0.rend2[i])"}
B 2 9800 -2630 10120 -2420 {flags=graph

y2=2.6e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=1.9e-06






color="7 6"
node="i(@r.xr10.x0.rend1[i])
i(@r.xr10.x0.rend2[i])"}
B 2 9800 -2040 10120 -1800 {flags=graph

y2=0.75
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.63




color="6 7"
node="\\"v_1 y -\\"
\\"y v_2 -\\""}
B 2 12260 -2950 12790 -2570 {flags=graph

y2=0.61
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.56




color=7
node="\\"y v_2 -\\""}
B 2 10790 -2390 11010 -2240 {flags=graph

y2=0.67
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.56




color="6 7"
node="\\"v_1 y -\\"
\\"y v_2 -\\""}
B 2 12260 -2090 12790 -1710 {flags=graph

y2=1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.0014




color="6 7 11 15 17"
node="y
\\"v_1 y - y v_2 - -\\"
\\"v_1 y - y v_2 - - 2 /\\"
\\"y v_1 y - y v_2 - - 2 / +\\"
\\"v_tot\\""}
B 2 770 -1990 1140 -1740 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-2.7e-11






color=7
node=v_bgr_ref}
B 2 770 -1700 1140 -1450 {flags=graph

y2=9.2e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0





color=4
node=i(@m.xm58.msky130_fd_pr__pfet_01v8[id])}
B 2 780 -2940 1150 -2690 {flags=graph

y2=0.78
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-4.2e-13






color=4
node=v_top}
B 2 7000 -1390 7300 -1180 {flags=graph
y1=0.27
y2=0.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=v_p}
B 2 8380 -3250.736356185054 8990 -2700.736356185054 {flags=graph

y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.4




color="12 17"
node="v_out_x
v_out_y"}
B 2 11670 -2520 12200 -2140 {flags=graph

y2=0.06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.012




color=6
node="\\"v_1 y - y v_2 - - \\""}
B 2 4110 -1390 4460 -1130 {flags=graph

y2=1.2410628
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=1.238811





color="6 7"
node="opamp_vin-
opamp_vin+"}
B 2 4110 -1090 4460 -830 {flags=graph

y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-8.7e-05







color="6 7"
node="v_cm+
v_cm-"}
B 2 4570 -1390 4920 -1130 {flags=graph

y2=0.002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.002





color=6
node="\\"opamp_vin- opamp_vin+ - \\""}
B 2 4570 -1090 4920 -830 {flags=graph

y2=0.002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=-0.002







color=6
node="\\"v_cm+ v_cm- - \\""}
B 2 4110 -780 4460 -520 {flags=graph

y2=0.77
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-8.7e-05








color="6 7"
node="v4_p1
v4_p2"
autoload=0}
B 2 7190 -190 7800 360 {flags=graph

y2=17
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=5.3



color=6
node="\\"-1 v_out_x v_out_y - x y - / *\\""}
B 2 2010 -1810 2380 -1560 {flags=graph

y2=0.75
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=3.9e-24






color=7
node=pfet_gate_10ua}
B 2 9860 -4270 10470 -3720 {flags=graph

y2=3
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=1











linewidth_mult=2
























y1=-1




color=7
node="\\"x y +\\""}
B 2 9860 -3650 10470 -3100 {flags=graph


ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0











linewidth_mult=2
























y1=-360




color=7
node="\\"ph(x) ph(y) + 180 -\\""
y2=-9.2e-05}
B 2 10590 -4270 11200 -3720 {flags=graph

y2=3.1491512
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=1











linewidth_mult=2
























y1=-0.96732884




color=7
node="\\"v_out_x v_out_y +\\""}
B 2 10590 -3650 11200 -3100 {flags=graph

y2=-4.9e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0











linewidth_mult=2
























y1=-180






color=7
node="\\"ph(v_out_x) ph(v_out_y) + 180 - 2 /\\""}
B 2 770 -2290 1140 -2040 {flags=graph

y2=0.86
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.7e-14







color=7
node=v_top}
B 2 2010 -1540 2380 -1290 {flags=graph

y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.0051





color=7
node=v_cur_ref_reg}
B 2 9860 -4900 10470 -4350 {flags=graph

y2=-2.5
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=1











linewidth_mult=2
























y1=-15




color=7
node="\\"x y + frequency /\\""}
B 2 10590 -4900 11200 -4350 {flags=graph

y2=2.7
ypos1=0
ypos2=2
divy=5
subdivy=8
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=1











linewidth_mult=2
























y1=-19




color=7
node="\\"v_out_x v_out_y + frequency /\\""}
B 2 1460 -410 1830 -160 {flags=graph

y2=1.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0





color=4
node=i(@m.xm65.msky130_fd_pr__pfet_01v8[id])}
B 2 770 -480 1140 -230 {flags=graph

y2=0.97
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.00026






color=7
node=asas}
B 2 770 -190 1140 60 {flags=graph

y2=1.2e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0





color=4
node=i(@m.xm64.msky130_fd_pr__pfet_01v8[id])}
B 2 2010 -300 2380 -50 {flags=graph

y2=0.55
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-1.9e-15






color=7
node=adad}
B 2 770 -780 1140 -530 {flags=graph

y2=0.86
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-5.7e-14







color=7
node=abab}
B 2 2010 -30 2380 220 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1
x2=1e+13
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.0016





color=7
node=dvdv}
B 2 11330 -3650 11940 -3100 {flags=graph

y2=-7.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0











linewidth_mult=2
























y1=-360






color=7
node="\\"ph(v_out_x) 180 -\\""}
B 2 8510 -4600 9040 -4220 {flags=graph

y2=28000
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=13
divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0











linewidth_mult=4
























y1=1900






color="7 7"
node="\\"1 @m.xm39.msky130_fd_pr__pfet_01v8[gds] / \\"
\\"1 @m.xm37.msky130_fd_pr__nfet_01v8[gds] / \\""}
B 2 7690 -3110 8120 -2800 {flags=graph
y1=2000
y2=74000
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color="7 7 7 7 6"
node="\\"1 @m.xm7.msky130_fd_pr__nfet_01v8[gds] /\\"
\\"1 @m.xm9.msky130_fd_pr__nfet_01v8[gds] /\\"
\\"1 @m.xm11.msky130_fd_pr__pfet_01v8[gds] /\\"
\\"1 @m.xm13.msky130_fd_pr__pfet_01v8[gds] /\\"


\\"@m.xm9.msky130_fd_pr__nfet_01v8[gm] 1 @m.xm9.msky130_fd_pr__nfet_01v8[gds] /  1 @m.xm7.msky130_fd_pr__nfet_01v8[gds] / * *\\""}
B 2 7690 -2740 8120 -2430 {flags=graph
y1=1600
y2=86000
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1
x2=1e+13
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=1


color="7 7 7 7 6"
node="\\"1 @m.xm7.msky130_fd_pr__nfet_01v8[gds] /\\"
\\"1 @m.xm9.msky130_fd_pr__nfet_01v8[gds] /\\"
\\"1 @m.xm11.msky130_fd_pr__pfet_01v8[gds] /\\"
\\"1 @m.xm13.msky130_fd_pr__pfet_01v8[gds] /\\"

\\"@m.xm11.msky130_fd_pr__pfet_01v8[gm] 1 @m.xm11.msky130_fd_pr__pfet_01v8[gds] /  1 @m.xm13.msky130_fd_pr__pfet_01v8[gds] / * *\\""}
T {VDS3} 3140 -3710 0 0 0.3 0.3 {}
T {VGS3-VTH3} 3640 -3640 0 0 0.3 0.3 {}
T {VTH3-VTH1} 3080 -3490 0 0 0.3 0.3 {}
T {VGS1-VTH1} 3590 -3430 0 0 0.3 0.3 {}
T {VDS1} 3130 -3270 0 0 0.3 0.3 {}
T {VDS4} 3880 -3650 0 0 0.3 0.3 {}
T {VGS4-VTH4} 4550 -3650 0 0 0.3 0.3 {}
T {VTH4-VTH2} 3820 -3480 0 0 0.3 0.3 {}
T {VGS2-VTH2} 4540 -3250 0 0 0.3 0.3 {}
T {VDS2} 4030 -3190 0 0 0.3 0.3 {}
T {Vb2} 3640 -3180 0 0 0.3 0.3 {}
T {Vb5} 4540 -3480 0 0 0.3 0.3 {}
T {VGS5-VTH5} 1920 -3530 0 0 0.3 0.3 {}
T {VDS6} 1460 -3370 0 0 0.3 0.3 {}
T {VDS43} 2210 -3650 0 0 0.3 0.3 {}
T {VGS43-VTH43} 2880 -3650 0 0 0.3 0.3 {}
T {VTH43-VTH6} 2150 -3480 0 0 0.3 0.3 {}
T {VGS6-VTH6} 2870 -3250 0 0 0.3 0.3 {}
T {VDS2} 2360 -3190 0 0 0.3 0.3 {}
T {Vb6} 1970 -3280 0 0 0.3 0.3 {}
T {Vb7} 2870 -3480 0 0 0.3 0.3 {}
T {VDS23} 4880 -3710 0 0 0.3 0.3 {}
T {VGS23-VTH23} 5380 -3640 0 0 0.3 0.3 {}
T {VTH23-VTH21} 4820 -3490 0 0 0.3 0.3 {}
T {VGS21-VTH21} 5330 -3430 0 0 0.3 0.3 {}
T {VDS21} 4870 -3270 0 0 0.3 0.3 {}
T {VDS24} 5620 -3650 0 0 0.3 0.3 {}
T {VGS24-VTH24} 6290 -3650 0 0 0.3 0.3 {}
T {VTH24-VTH22} 5560 -3480 0 0 0.3 0.3 {}
T {VGS22-VTH22} 6280 -3250 0 0 0.3 0.3 {}
T {VDS2} 5770 -3190 0 0 0.3 0.3 {}
T {Vb2} 5380 -3180 0 0 0.3 0.3 {}
T {Vb3} 6280 -3480 0 0 0.3 0.3 {}
T {VTH20-VTH19} 8100 -2070 0 0 0.3 0.3 {}
T {VDS19} 7750 -1920 0 0 0.3 0.3 {}
T {VGS19} 7560 -1920 0 0 0.3 0.3 {}
T {VGS19-VTH19} 7910 -1920 0 0 0.3 0.3 {}
T {VDS20} 7750 -2070 0 0 0.3 0.3 {}
T {VGS20} 7560 -2070 0 0 0.3 0.3 {}
T {VGS20-VTH20} 7910 -2070 0 0 0.3 0.3 {}
T {VGS10-VTH10} 7540 -2230 0 0 0.3 0.3 {}
T {VGS11} 6300 -2590 0 0 0.3 0.3 {}
T {VDS11} 6110 -2590 0 0 0.3 0.3 {}
T {VGS11-VTH11} 6470 -2590 0 0 0.3 0.3 {}
T {VGS9} 6300 -2180 0 0 0.3 0.3 {}
T {VDS9} 6110 -2180 0 0 0.3 0.3 {}
T {VGS9-VTH9} 6470 -2180 0 0 0.3 0.3 {}
T {VGS7} 6300 -1940 0 0 0.3 0.3 {}
T {VDS7} 6110 -1940 0 0 0.3 0.3 {}
T {VGS7-VTH7} 6470 -1940 0 0 0.3 0.3 {}
T {N 50uA} 1870 -3100 0 0 1 1 {}
T {N 50uA} 2640 -3100 0 0 1 1 {}
T {P 100uA} 5130 -2420 0 0 1 1 {}
T {P 20uA} 7060 -3050 0 0 1 1 {}
T {N 2uA} 9030 -3370 0 0 1 1 {}
T {N 20uA} 8550 -1410 0 0 1 1 {}
T {N 30uA} 10150 -2010 0 0 1 1 {}
T {P 30uA} 10170 -2700 0 0 1 1 {}
T {P 30uA} 11300 -2700 0 1 1 1 {}
T {N 30uA} 11320 -2010 0 1 1 1 {}
T {N 50uA} 3540 -3100 0 0 1 1 {}
T {N 50uA} 4310 -3100 0 0 1 1 {}
T {N 50uA} 5270 -3100 0 0 1 1 {}
T {N 50uA} 6040 -3100 0 0 1 1 {}
T {exactly at 10uA, 0.35/12.4} 2110 -520 0 0 0.4 0.4 {}
T {C 33/33 2.203*10^-12 F
R 1.51/1 460.6
PM = 88.9

C 20/20 8.152*10^-13 F
R 0.92/1 460.6 PM = 46.9
R 1.57/1 443 PM = 56.2

C 25/25 1.269*10^-12 F
R 1.19/1 584.4
PM = 66.4} 9370 -4030 0 0 0.4 0.4 {}
N 6660 -1770 6660 -1680 {lab=V_p}
N 6660 -1680 7410 -1680 {lab=V_p}
N 7410 -1770 7410 -1680 {lab=V_p}
N 6660 -2380 6660 -1830 {lab=VD1}
N 7410 -2380 7410 -1830 {lab=VD2}
N 6700 -2410 7370 -2410 {lab=Vb1}
N 6660 -2740 6660 -2440 {lab=X}
N 7410 -2740 7410 -2440 {lab=Y}
N 6660 -3160 6660 -2800 {lab=VD7}
N 7410 -3160 7410 -2800 {lab=VD6}
N 6700 -2770 7370 -2770 {lab=Vb6}
N 7410 -2770 7480 -2770 {lab=VD6}
N 7480 -2840 7480 -2770 {lab=VD6}
N 7410 -2840 7480 -2840 {lab=VD6}
N 6590 -2770 6660 -2770 {lab=VD7}
N 6590 -2840 6590 -2770 {lab=VD7}
N 6590 -2840 6660 -2840 {lab=VD7}
N 6660 -3340 6660 -3220 {lab=VDD}
N 7410 -3340 7410 -3220 {lab=VDD}
N 6700 -3190 7370 -3190 {lab=Vb7}
N 7410 -3190 7480 -3190 {lab=VDD}
N 7480 -3260 7480 -3190 {lab=VDD}
N 7410 -3260 7480 -3260 {lab=VDD}
N 6590 -3190 6660 -3190 {lab=VDD}
N 6590 -3260 6590 -3190 {lab=VDD}
N 6590 -3260 6660 -3260 {lab=VDD}
N 6660 -3340 7410 -3340 {lab=VDD}
N 6610 -2410 6660 -2410 {lab=GND}
N 6610 -2410 6610 -2350 {lab=GND}
N 6610 -2350 7470 -2350 {lab=GND}
N 7470 -2410 7470 -2350 {lab=GND}
N 7410 -2410 7470 -2410 {lab=GND}
N 6840 -3400 6840 -3340 {lab=VDD}
N 7110 -1800 7410 -1800 {lab=GND}
N 6660 -1800 7110 -1800 {lab=GND}
N 6960 -1680 6960 -1570 {lab=V_p}
N 7110 -1800 7110 -1540 {lab=GND}
N 6960 -1540 7110 -1540 {lab=GND}
N 6960 -1510 6960 -1420 {lab=GND}
N 6960 -1460 7110 -1460 {lab=GND}
N 7110 -1540 7110 -1460 {lab=GND}
N 7450 -1800 7540 -1800 {lab=opamp_Vin+}
N 5060 -1680 5060 -1570 {lab=V_p_mir}
N 4980 -1540 5060 -1540 {lab=GND}
N 5060 -1510 5060 -1420 {lab=GND}
N 4980 -1460 5060 -1460 {lab=GND}
N 4980 -1540 4980 -1460 {lab=GND}
N 5100 -1540 6920 -1540 {lab=VGS9}
N 5060 -2460 5060 -2400 {lab=VDD}
N 5140 -1800 5230 -1800 {lab=GND}
N 4900 -1800 5140 -1800 {lab=GND}
N 4900 -1770 4900 -1680 {lab=V_p_mir}
N 4900 -1680 5230 -1680 {lab=V_p_mir}
N 5230 -1770 5230 -1680 {lab=V_p_mir}
N 4980 -1800 4980 -1540 {lab=GND}
N 4900 -1950 4900 -1830 {lab=VGS9}
N 4900 -1950 5230 -1950 {lab=VGS9}
N 5230 -1950 5230 -1830 {lab=VGS9}
N 5060 -2150 5060 -1950 {lab=VGS9}
N 5270 -1800 5340 -1800 {lab=opamp_Vin-}
N 4790 -1800 4860 -1800 {lab=opamp_Vin+}
N 5060 -2070 5460 -2070 {lab=VGS9}
N 5460 -2070 5460 -1540 {lab=VGS9}
N 6960 -2060 6960 -1980 {lab=Vb1}
N 6960 -1950 7110 -1950 {lab=GND}
N 6960 -1920 6960 -1680 {lab=V_p}
N 6960 -2410 6960 -2120 {lab=Vb1}
N 6830 -1950 6920 -1950 {lab=Vb1}
N 6830 -2210 6830 -1950 {lab=Vb1}
N 6830 -2210 6960 -2210 {lab=Vb1}
N 6960 -2980 6960 -2410 {lab=Vb1}
N 6960 -3340 6960 -3040 {lab=VDD}
N 5150 -3320 5150 -3200 {lab=Vb2}
N 5930 -3320 5930 -3200 {lab=Vb3}
N 5150 -3530 5150 -3380 {lab=V1}
N 5930 -3530 5930 -3380 {lab=V2}
N 5860 -3350 5930 -3350 {lab=V2}
N 5860 -3420 5860 -3350 {lab=V2}
N 5860 -3420 5930 -3420 {lab=V2}
N 5080 -3350 5150 -3350 {lab=V1}
N 5080 -3420 5080 -3350 {lab=V1}
N 5080 -3420 5150 -3420 {lab=V1}
N 5150 -3710 5150 -3590 {lab=VDD}
N 5930 -3710 5930 -3590 {lab=VDD}
N 5860 -3560 5930 -3560 {lab=VDD}
N 5860 -3630 5860 -3560 {lab=VDD}
N 5860 -3630 5930 -3630 {lab=VDD}
N 5080 -3560 5150 -3560 {lab=VDD}
N 5080 -3630 5080 -3560 {lab=VDD}
N 5080 -3630 5150 -3630 {lab=VDD}
N 5350 -3770 5350 -3710 {lab=VDD}
N 5150 -3710 5930 -3710 {lab=VDD}
N 5190 -3560 5270 -3560 {lab=Vb2}
N 5190 -3350 5270 -3350 {lab=Vb2}
N 5970 -3560 6050 -3560 {lab=Vb3}
N 6050 -3560 6050 -3250 {lab=Vb3}
N 5930 -3250 6050 -3250 {lab=Vb3}
N 5270 -3560 5270 -3250 {lab=Vb2}
N 5150 -3250 5270 -3250 {lab=Vb2}
N 5970 -3350 6130 -3350 {lab=Vb2}
N 10440 -2230 10440 -2180 {lab=VDD}
N 10440 -2020 10440 -1960 {lab=GND}
N 10440 -2120 10440 -2080 {lab=V_4}
N 10440 -2460 10440 -2410 {lab=GND}
N 10440 -2570 10440 -2520 {lab=V_3}
N 10320 -2490 10320 -2150 {lab=X}
N 11070 -2490 11140 -2490 {lab=Y}
N 11140 -2490 11140 -2150 {lab=Y}
N 11070 -2150 11140 -2150 {lab=Y}
N 10200 -2330 10320 -2330 {lab=X}
N 11140 -2330 11260 -2330 {lab=Y}
N 10880 -2540 11030 -2540 {lab=V_1}
N 10880 -2100 11030 -2100 {lab=V_2}
N 10440 -2490 10520 -2490 {lab=VDD}
N 10440 -2650 10520 -2650 {lab=VDD}
N 10440 -2680 10440 -2620 {lab=VDD}
N 10520 -2650 10520 -2490 {lab=VDD}
N 10440 -1990 10520 -1990 {lab=GND}
N 10440 -2150 10520 -2150 {lab=GND}
N 10520 -2150 10520 -1990 {lab=GND}
N 11030 -2230 11030 -2180 {lab=VDD}
N 11030 -2020 11030 -1960 {lab=GND}
N 11030 -2120 11030 -2080 {lab=V_2}
N 11030 -2460 11030 -2410 {lab=GND}
N 11030 -2570 11030 -2520 {lab=V_1}
N 10950 -2490 11030 -2490 {lab=VDD}
N 10950 -2650 11030 -2650 {lab=VDD}
N 11030 -2680 11030 -2620 {lab=VDD}
N 10950 -2650 10950 -2490 {lab=VDD}
N 10950 -1990 11030 -1990 {lab=GND}
N 10950 -2150 11030 -2150 {lab=GND}
N 10950 -2150 10950 -1990 {lab=GND}
N 10740 -2540 10740 -2100 {lab=V_tot}
N 9410 -1730 9410 -1660 {lab=V_err_p}
N 9170 -1730 9410 -1730 {lab=V_err_p}
N 9170 -1730 9170 -1660 {lab=V_err_p}
N 9290 -1780 9290 -1730 {lab=V_err_p}
N 9290 -1890 9290 -1840 {lab=VDD}
N 9410 -1600 9410 -1480 {lab=err_opamp_mir}
N 9170 -1600 9170 -1480 {lab=err_opamp_out}
N 9410 -1420 9410 -1370 {lab=GND}
N 9170 -1370 9410 -1370 {lab=GND}
N 9170 -1420 9170 -1370 {lab=GND}
N 9290 -1370 9290 -1320 {lab=GND}
N 9170 -1630 9410 -1630 {lab=VDD}
N 9210 -1450 9370 -1450 {lab=err_opamp_mir}
N 9130 -1450 9170 -1450 {lab=GND}
N 9130 -1450 9130 -1400 {lab=GND}
N 9130 -1400 9170 -1400 {lab=GND}
N 9410 -1450 9450 -1450 {lab=GND}
N 9450 -1450 9450 -1400 {lab=GND}
N 9410 -1400 9450 -1400 {lab=GND}
N 9310 -1530 9410 -1530 {lab=err_opamp_mir}
N 9310 -1530 9310 -1450 {lab=err_opamp_mir}
N 10740 -2100 10740 -1630 {lab=V_tot}
N 9040 -1630 9130 -1630 {lab=asas}
N 7110 -1540 7260 -1540 {lab=GND}
N 7110 -1460 7260 -1460 {lab=GND}
N 7260 -1510 7260 -1460 {lab=GND}
N 7260 -1680 7260 -1570 {lab=V_p}
N 9450 -1630 10740 -1630 {lab=V_tot}
N 11520 -2630 11520 -2570 {lab=V_ref}
N 9290 -1810 9330 -1810 {lab=VDD}
N 9330 -1870 9330 -1810 {lab=VDD}
N 9290 -1870 9330 -1870 {lab=VDD}
N 9330 -1810 9330 -1630 {lab=VDD}
N 8330 -1730 8330 -1660 {lab=V_err_mir_p}
N 8330 -1730 8570 -1730 {lab=V_err_mir_p}
N 8570 -1730 8570 -1660 {lab=V_err_mir_p}
N 8450 -1780 8450 -1730 {lab=V_err_mir_p}
N 8450 -1890 8450 -1840 {lab=VDD}
N 8330 -1630 8570 -1630 {lab=VDD}
N 8610 -1630 8700 -1630 {lab=V_ref}
N 8410 -1810 8450 -1810 {lab=VDD}
N 8410 -1870 8410 -1810 {lab=VDD}
N 8410 -1870 8450 -1870 {lab=VDD}
N 8410 -1810 8410 -1630 {lab=VDD}
N 8490 -1810 9250 -1810 {lab=V_gate}
N 8330 -1600 8330 -1540 {lab=V_gate}
N 8330 -1540 8570 -1540 {lab=V_gate}
N 8570 -1600 8570 -1540 {lab=V_gate}
N 8450 -1540 8450 -1420 {lab=V_gate}
N 8200 -1630 8290 -1630 {lab=V_tot}
N 8450 -1360 8450 -1310 {lab=GND}
N 8890 -1810 8890 -1480 {lab=V_gate}
N 8450 -1480 8890 -1480 {lab=V_gate}
N 7300 -1540 8000 -1540 {lab=err_opamp_out}
N 8000 -1540 8000 -1180 {lab=err_opamp_out}
N 8000 -1180 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9170 -1550 {lab=err_opamp_out}
N 7110 -2090 7110 -1800 {lab=GND}
N 7110 -2350 7110 -2090 {lab=GND}
N 8200 -4100 8200 -3460 {lab=V_OUT_X}
N 9270 -4100 9270 -3460 {lab=V_OUT_Y}
N 9270 -4130 9340 -4130 {lab=VDD}
N 9340 -4200 9340 -4130 {lab=VDD}
N 9270 -4200 9340 -4200 {lab=VDD}
N 8130 -4130 8200 -4130 {lab=VDD}
N 8130 -4200 8200 -4200 {lab=VDD}
N 8130 -4200 8130 -4130 {lab=VDD}
N 8200 -4230 8200 -4160 {lab=VDD}
N 9270 -4230 9270 -4160 {lab=VDD}
N 8200 -3400 8200 -3230 {lab=GND}
N 9270 -3400 9270 -3230 {lab=GND}
N 9270 -3360 9340 -3360 {lab=GND}
N 9340 -3430 9340 -3360 {lab=GND}
N 9270 -3430 9340 -3430 {lab=GND}
N 8130 -3360 8200 -3360 {lab=GND}
N 8130 -3430 8200 -3430 {lab=GND}
N 8130 -3430 8130 -3360 {lab=GND}
N 8240 -4130 8570 -4130 {lab=X}
N 8900 -4130 9230 -4130 {lab=Y}
N 7960 -3620 8200 -3620 {lab=V_OUT_X}
N 9270 -3620 9520 -3620 {lab=V_OUT_Y}
N 9140 -3550 9270 -3550 {lab=V_OUT_Y}
N 8740 -3430 9230 -3430 {lab=V_b}
N 8800 -3550 9080 -3550 {lab=V_b}
N 8800 -3550 8800 -3430 {lab=V_b}
N 8200 -3550 8330 -3550 {lab=V_OUT_X}
N 8390 -3550 8680 -3550 {lab=V_b}
N 8240 -3430 8740 -3430 {lab=V_b}
N 8680 -3550 8680 -3430 {lab=V_b}
N 10650 -2100 10820 -2100 {lab=V_tot}
N 10650 -2540 10820 -2540 {lab=V_tot}
N 10440 -2540 10590 -2540 {lab=V_3}
N 10440 -2100 10590 -2100 {lab=V_4}
N 10320 -2490 10400 -2490 {lab=X}
N 10320 -2150 10400 -2150 {lab=X}
N 6490 -1800 6620 -1800 {lab=opamp_Vin-}
N 11030 -2100 11150 -2100 {lab=V_2}
N 11030 -2540 11120 -2540 {lab=V_1}
N 6660 -1680 7410 -1680 {lab=V_p}
N 6140 -1800 6490 -1800 {lab=opamp_Vin-}
N 5340 -1800 6140 -1800 {lab=opamp_Vin-}
N 4790 -1900 6140 -1900 {lab=opamp_Vin+}
N 4790 -1900 4790 -1800 {lab=opamp_Vin+}
N 7540 -1900 7540 -1800 {lab=opamp_Vin+}
N 6140 -1900 7540 -1900 {lab=opamp_Vin+}
N 6490 -1740 6490 -1670 {lab=opamp_Vin-}
N 7540 -1740 7540 -1670 {lab=opamp_Vin+}
N 5060 -2340 5060 -2150 {lab=VGS9}
N 3420 -3320 3420 -3200 {lab=Vb4}
N 4200 -3320 4200 -3200 {lab=Vb5}
N 3420 -3530 3420 -3380 {lab=V3}
N 4200 -3530 4200 -3380 {lab=V4}
N 4130 -3350 4200 -3350 {lab=V4}
N 4130 -3420 4130 -3350 {lab=V4}
N 4130 -3420 4200 -3420 {lab=V4}
N 3350 -3350 3420 -3350 {lab=V3}
N 3350 -3420 3350 -3350 {lab=V3}
N 3350 -3420 3420 -3420 {lab=V3}
N 3420 -3710 3420 -3590 {lab=VDD}
N 4200 -3710 4200 -3590 {lab=VDD}
N 4130 -3560 4200 -3560 {lab=VDD}
N 4130 -3630 4130 -3560 {lab=VDD}
N 4130 -3630 4200 -3630 {lab=VDD}
N 3350 -3560 3420 -3560 {lab=VDD}
N 3350 -3630 3350 -3560 {lab=VDD}
N 3350 -3630 3420 -3630 {lab=VDD}
N 3620 -3770 3620 -3710 {lab=VDD}
N 3420 -3710 4200 -3710 {lab=VDD}
N 3460 -3560 3540 -3560 {lab=Vb4}
N 3460 -3350 3540 -3350 {lab=Vb4}
N 4240 -3560 4320 -3560 {lab=Vb5}
N 4320 -3560 4320 -3250 {lab=Vb5}
N 4200 -3250 4320 -3250 {lab=Vb5}
N 3540 -3560 3540 -3250 {lab=Vb4}
N 3420 -3250 3540 -3250 {lab=Vb4}
N 4240 -3350 4400 -3350 {lab=Vb4}
N 1750 -3420 1750 -3210 {lab=Vb6}
N 2530 -3320 2530 -3200 {lab=Vb7}
N 2530 -3530 2530 -3380 {lab=V5}
N 2460 -3350 2530 -3350 {lab=V5}
N 2460 -3420 2460 -3350 {lab=V5}
N 2460 -3420 2530 -3420 {lab=V5}
N 1680 -3450 1750 -3450 {lab=VDD}
N 1680 -3520 1680 -3450 {lab=VDD}
N 1680 -3520 1750 -3520 {lab=VDD}
N 2530 -3710 2530 -3590 {lab=VDD}
N 2460 -3560 2530 -3560 {lab=VDD}
N 2460 -3630 2460 -3560 {lab=VDD}
N 2460 -3630 2530 -3630 {lab=VDD}
N 1950 -3770 1950 -3710 {lab=VDD}
N 1750 -3710 2530 -3710 {lab=VDD}
N 1790 -3450 1870 -3450 {lab=Vb6}
N 2570 -3560 2650 -3560 {lab=Vb7}
N 2650 -3560 2650 -3250 {lab=Vb7}
N 2530 -3250 2650 -3250 {lab=Vb7}
N 1750 -3350 1870 -3350 {lab=Vb6}
N 2570 -3350 2730 -3350 {lab=Vb6}
N 1870 -3450 1870 -3350 {lab=Vb6}
N 1750 -3710 1750 -3480 {lab=VDD}
N 6960 -2120 6960 -2060 {lab=Vb1}
N 10320 -2100 10440 -2100 {lab=V_4}
N 10350 -2540 10440 -2540 {lab=V_3}
N 930 -2480 1200 -2480 {lab=V_TOP}
N 2440 -2350 2440 -2300 {lab=VDD}
N 2440 -2270 2490 -2270 {lab=VDD}
N 2490 -2330 2490 -2270 {lab=VDD}
N 2440 -2330 2490 -2330 {lab=VDD}
N 2310 -2270 2400 -2270 {lab=pfet_gate_10uA}
N 2440 -1970 2440 -1910 {lab=GND}
N 2390 -1940 2440 -1940 {lab=GND}
N 2390 -2000 2390 -1940 {lab=GND}
N 2390 -2000 2440 -2000 {lab=GND}
N 2440 -2240 2440 -2030 {lab=nfet_gate_10uA}
N 1750 -3050 1750 -2990 {lab=GND}
N 1750 -3020 1800 -3020 {lab=GND}
N 1800 -3080 1800 -3020 {lab=GND}
N 1750 -3080 1800 -3080 {lab=GND}
N 1750 -3210 1750 -3110 {lab=Vb6}
N 2510 -2070 2510 -2000 {lab=nfet_gate_10uA}
N 2440 -2070 2510 -2070 {lab=nfet_gate_10uA}
N 2480 -2000 2610 -2000 {lab=nfet_gate_10uA}
N 1640 -3080 1710 -3080 {lab=nfet_gate_10uA}
N 2530 -3040 2530 -2980 {lab=GND}
N 2530 -3010 2580 -3010 {lab=GND}
N 2580 -3070 2580 -3010 {lab=GND}
N 2530 -3070 2580 -3070 {lab=GND}
N 2530 -3200 2530 -3100 {lab=Vb7}
N 2420 -3070 2490 -3070 {lab=nfet_gate_10uA}
N 3420 -3200 3420 -3100 {lab=Vb4}
N 4200 -3200 4200 -3100 {lab=Vb5}
N 5150 -3200 5150 -3100 {lab=Vb2}
N 5930 -3200 5930 -3100 {lab=Vb3}
N 6960 -3010 7010 -3010 {lab=VDD}
N 7010 -3070 7010 -3010 {lab=VDD}
N 6960 -3070 7010 -3070 {lab=VDD}
N 6860 -3010 6920 -3010 {lab=pfet_gate_10uA}
N 5060 -2370 5110 -2370 {lab=VDD}
N 5110 -2430 5110 -2370 {lab=VDD}
N 5060 -2430 5110 -2430 {lab=VDD}
N 4930 -2370 5020 -2370 {lab=pfet_gate_10uA}
N 8450 -1330 8500 -1330 {lab=GND}
N 8500 -1390 8500 -1330 {lab=GND}
N 8450 -1390 8500 -1390 {lab=GND}
N 8340 -1390 8410 -1390 {lab=nfet_gate_10uA}
N 10490 -2050 10490 -1990 {lab=GND}
N 10440 -2050 10490 -2050 {lab=GND}
N 10330 -2050 10400 -2050 {lab=nfet_gate_10uA}
N 10440 -2590 10490 -2590 {lab=VDD}
N 10490 -2650 10490 -2590 {lab=VDD}
N 10340 -2590 10400 -2590 {lab=pfet_gate_10uA}
N 10980 -2590 11030 -2590 {lab=VDD}
N 10980 -2650 10980 -2590 {lab=VDD}
N 11070 -2590 11130 -2590 {lab=pfet_gate_10uA}
N 10980 -2050 10980 -1990 {lab=GND}
N 10980 -2050 11030 -2050 {lab=GND}
N 11070 -2050 11140 -2050 {lab=nfet_gate_10uA}
N 1240 -1700 1240 -1590 {lab=GND}
N 1240 -2590 1240 -2510 {
lab=VDD}
N 1240 -2480 1280 -2480 {lab=VDD}
N 1280 -2550 1280 -2480 {lab=VDD}
N 1240 -2550 1280 -2550 {lab=VDD}
N 1240 -2290 1340 -2290 {lab=V_BGR_REF}
N 1240 -2450 1240 -1760 {lab=V_BGR_REF}
N 1940 -2270 1980 -2270 {lab=VDD}
N 1980 -2340 1980 -2270 {lab=VDD}
N 1940 -2340 1980 -2340 {lab=VDD}
N 1690 -2270 1900 -2270 {lab=adad}
N 1470 -2250 1560 -2250 {lab=V_CUR_REF_REG}
N 1470 -2250 1470 -1990 {lab=V_CUR_REF_REG}
N 1470 -1990 1940 -1990 {lab=V_CUR_REF_REG}
N 1940 -2240 1940 -1910 {lab=V_CUR_REF_REG}
N 1340 -2290 1560 -2290 {lab=V_BGR_REF}
N 1240 -2590 1940 -2590 {lab=VDD}
N 1940 -2590 1940 -2300 {lab=VDD}
N 1240 -1590 1940 -1590 {lab=GND}
N 1940 -1850 1940 -1590 {lab=GND}
N 1840 -2270 1840 -2170 {lab=adad}
N 1840 -2170 2020 -2170 {lab=adad}
N 3420 -3050 3420 -2990 {lab=GND}
N 3420 -3020 3470 -3020 {lab=GND}
N 3470 -3080 3470 -3020 {lab=GND}
N 3420 -3080 3470 -3080 {lab=GND}
N 3310 -3080 3380 -3080 {lab=nfet_gate_10uA}
N 4200 -3040 4200 -2980 {lab=GND}
N 4200 -3010 4250 -3010 {lab=GND}
N 4250 -3070 4250 -3010 {lab=GND}
N 4200 -3070 4250 -3070 {lab=GND}
N 4090 -3070 4160 -3070 {lab=nfet_gate_10uA}
N 5150 -3050 5150 -2990 {lab=GND}
N 5150 -3020 5200 -3020 {lab=GND}
N 5200 -3080 5200 -3020 {lab=GND}
N 5150 -3080 5200 -3080 {lab=GND}
N 5040 -3080 5110 -3080 {lab=nfet_gate_10uA}
N 5930 -3040 5930 -2980 {lab=GND}
N 5930 -3010 5980 -3010 {lab=GND}
N 5980 -3070 5980 -3010 {lab=GND}
N 5930 -3070 5980 -3070 {lab=GND}
N 5820 -3070 5890 -3070 {lab=nfet_gate_10uA}
N 6490 -1800 6490 -1740 {lab=opamp_Vin-}
N 7540 -1800 7540 -1740 {lab=opamp_Vin+}
N 1120 -2500 1120 -2480 {lab=V_TOP}
N 1120 -2590 1120 -2560 {lab=VDD}
N 1120 -2590 1240 -2590 {lab=VDD}
N 1120 -2370 1240 -2370 {lab=V_BGR_REF}
N 8950 -4130 8950 -4050 {lab=Y}
N 8520 -4130 8520 -4050 {lab=X}
N 9130 -3900 9270 -3900 {lab=V_OUT_Y}
N 8200 -3900 8340 -3900 {lab=V_OUT_X}
N 9460 -3480 9460 -3400 {lab=GND}
N 9460 -3620 9460 -3540 {lab=V_OUT_Y}
N 8030 -3480 8030 -3400 {lab=GND}
N 8030 -3620 8030 -3540 {lab=V_OUT_X}
N 930 -970 1200 -970 {lab=abab}
N 1240 -190 1240 -80 {lab=GND}
N 1240 -1080 1240 -1000 {
lab=VDD}
N 1240 -970 1280 -970 {lab=VDD}
N 1280 -1040 1280 -970 {lab=VDD}
N 1240 -1040 1280 -1040 {lab=VDD}
N 1240 -780 1340 -780 {lab=asas}
N 1240 -940 1240 -250 {lab=asas}
N 1940 -760 1980 -760 {lab=VDD}
N 1980 -830 1980 -760 {lab=VDD}
N 1940 -830 1980 -830 {lab=VDD}
N 1690 -760 1900 -760 {lab=pfet_gate_10uA}
N 1470 -740 1560 -740 {lab=dvdv}
N 1470 -740 1470 -480 {lab=dvdv}
N 1470 -480 1940 -480 {lab=dvdv}
N 1940 -730 1940 -400 {lab=dvdv}
N 1340 -780 1560 -780 {lab=asas}
N 1240 -1080 1940 -1080 {lab=VDD}
N 1940 -1080 1940 -790 {lab=VDD}
N 1240 -80 1940 -80 {lab=GND}
N 1940 -340 1940 -80 {lab=GND}
N 1840 -760 1840 -660 {lab=pfet_gate_10uA}
N 1840 -660 2020 -660 {lab=pfet_gate_10uA}
N 1120 -990 1120 -970 {lab=abab}
N 1120 -1080 1120 -1050 {lab=VDD}
N 1120 -1080 1240 -1080 {lab=VDD}
N 1120 -860 1240 -860 {lab=asas}
N 7700 -3980 7700 -3860 {lab=vzvz}
N 7700 -4190 7700 -4040 {lab=hghg}
N 7630 -4010 7700 -4010 {lab=hghg}
N 7630 -4080 7630 -4010 {lab=hghg}
N 7630 -4080 7700 -4080 {lab=hghg}
N 7700 -4370 7700 -4250 {lab=VDD}
N 7630 -4220 7700 -4220 {lab=VDD}
N 7630 -4290 7630 -4220 {lab=VDD}
N 7630 -4290 7700 -4290 {lab=VDD}
N 7740 -4220 7820 -4220 {lab=hghg}
N 7740 -4010 7820 -4010 {lab=vzvz}
N 7700 -3860 7700 -3760 {lab=vzvz}
N 7700 -3710 7700 -3650 {lab=GND}
N 7700 -3680 7750 -3680 {lab=GND}
N 7750 -3740 7750 -3680 {lab=GND}
N 7700 -3740 7750 -3740 {lab=GND}
N 7590 -3740 7660 -3740 {lab=VGS9}
N 7820 -4220 7820 -4140 {lab=hghg}
N 7700 -4140 7820 -4140 {lab=hghg}
N 7820 -4010 7820 -3930 {lab=vzvz}
N 7700 -3930 7820 -3930 {lab=vzvz}
N 8200 -4200 8370 -4200 {lab=VDD}
N 9100 -4200 9270 -4200 {lab=VDD}
N 8950 -3990 8950 -3900 {lab=#net1}
N 8520 -3990 8520 -3900 {lab=#net2}
N 8400 -3900 8520 -3900 {lab=#net2}
N 8950 -3900 9070 -3900 {lab=#net1}
N 8370 -4200 8370 -4020 {lab=VDD}
N 9100 -4200 9100 -4020 {lab=VDD}
C {devices/vsource.sym} 1410 -2760 0 0 {name=VDD value=1.8 savecurrent=false
* "pwl(0 0 10us 0 11us 1.8)"}
C {devices/gnd.sym} 1410 -2730 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 1410 -2790 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 860 -3050 0 0 {name=CORNER only_toplevel=false corner=tt}
C {sky130_fd_pr/nfet_01v8.sym} 6640 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7430 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6680 -2410 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7390 -2410 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 6840 -3400 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 6830 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb7}
C {lab_wire.sym} 6830 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb6}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1540 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 6960 -1420 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 6490 -1610 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5080 -1540 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 5060 -1420 0 0 {name=l14 lab=GND}
C {vdd.sym} 5060 -2460 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 4880 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5250 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1950 0 0 {name=M19
W=1
L=1.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6660 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3350 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3350 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3560 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3560 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 5350 -3770 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 6050 -3560 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 5270 -3350 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 6130 -3350 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 7410 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 10420 -2150 0 0 {name=M25
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10420 -2490 0 0 {name=M26
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 10440 -2230 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 10440 -1960 0 0 {name=l20 lab=GND}
C {vdd.sym} 10440 -2680 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 10440 -2410 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 10200 -2330 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 11260 -2330 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2540 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2560 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2100 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2080 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2540 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 10850 -2560 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2100 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10850 -2080 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 10740 -2330 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 11050 -2150 0 1 {name=M27
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11050 -2490 0 1 {name=M28
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 11030 -2230 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 11030 -1960 0 1 {name=l28 lab=GND}
C {vdd.sym} 11030 -2680 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 11030 -2410 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 9430 -1630 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -1630 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 9290 -1890 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 9390 -1450 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9190 -1450 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9290 -1320 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 9040 -1630 0 0 {name=p28 sig_type=std_logic lab=asas}
C {devices/vsource.sym} 11520 -2540 0 1 {name=Vref value=0.9 savecurrent=false
}
C {devices/gnd.sym} 11520 -2510 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 11520 -2630 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 9530 -1630 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 9270 -1810 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8310 -1630 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8590 -1630 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 8450 -1890 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 8700 -1630 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 8200 -1630 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8470 -1810 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8450 -1310 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 7540 -1610 0 0 {name=l36 lab=GND
value="sin(1.20 0.001 1Meg)"}
C {devices/vsource.sym} 6490 -1640 0 1 {name=V2 value="sin(1.24 -0.001 100k)" savecurrent=false
* "sin(1.24 -0.001 1Meg)"
* "1.24 AC -1"
* "sin(0.2 -0.001 1Meg)"}
C {devices/vsource.sym} 7540 -1640 0 0 {name=V1 value="sin(1.24 0.001 100k)" savecurrent=false
* "sin(1.24 0.001 1Meg)"
* "1.24 AC 1"
* "sin(1.57 0.001 1Meg)"}
C {sky130_fd_pr/nfet_01v8.sym} 8220 -3430 0 1 {name=M37
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9250 -3430 0 0 {name=M38
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8220 -4130 0 1 {name=M39
W=59
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9250 -4130 0 0 {name=M40
W=59
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8570 -4130 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 8900 -4130 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 7960 -3620 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 9520 -3620 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 8200 -4230 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 8200 -3230 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9110 -3550 3 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 9110 -3570 2 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8360 -3550 1 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8360 -3570 2 1 {name=l40 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7280 -1540 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7540 -1690 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 6490 -1690 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {simulator_commands_shown.sym} 80 -3400 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.x1.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm5.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__nfet_01v8[vth]
+@m.x1.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.x1.xm8.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm8.msky130_fd_pr__pfet_01v8[vth]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm2.msky130_fd_pr__nfet_01v8[vth]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x2.xm3.msky130_fd_pr__nfet_01v8[vth]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x2.xm7.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x2.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm3.msky130_fd_pr__pfet_01v8[vth]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[vth]
+@m.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.xm5.msky130_fd_pr__pfet_01v8[vth]
+@m.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[gds]
+@m.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[gds]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__nfet_01v8[gm]
+@m.xm10.msky130_fd_pr__nfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gm]
+@m.xm11.msky130_fd_pr__pfet_01v8[gds]
+@m.xm11.msky130_fd_pr__pfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gds]
+@m.xm12.msky130_fd_pr__pfet_01v8[gm]
+@m.xm12.msky130_fd_pr__pfet_01v8[vth]
+@m.xm12.msky130_fd_pr__pfet_01v8[gds]
+@m.xm13.msky130_fd_pr__pfet_01v8[gm]
+@m.xm13.msky130_fd_pr__pfet_01v8[gds]
+@m.xm13.msky130_fd_pr__pfet_01v8[vth]
+@m.xm13.msky130_fd_pr__pfet_01v8[gds]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm14.msky130_fd_pr__pfet_01v8[gds]
+@m.xm15.msky130_fd_pr__nfet_01v8[gm]
+@m.xm15.msky130_fd_pr__nfet_01v8[vth]
+@m.xm16.msky130_fd_pr__nfet_01v8[gm]
+@m.xm16.msky130_fd_pr__nfet_01v8[vth]
+@m.xm17.msky130_fd_pr__nfet_01v8[gm]
+@m.xm17.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__pfet_01v8[gm]
+@m.xm21.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[gm]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[gm]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]
+@m.xm36.msky130_fd_pr__pfet_01v8[gm]
+@m.xm36.msky130_fd_pr__pfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gds]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gds]
+@m.xm39.msky130_fd_pr__pfet_01v8[gm]
+@m.xm39.msky130_fd_pr__pfet_01v8[vth]
+@m.xm39.msky130_fd_pr__pfet_01v8[gds]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gds]
+@m.xm41.msky130_fd_pr__nfet_01v8[gm]
+@m.xm41.msky130_fd_pr__nfet_01v8[vth]
+@m.xm42.msky130_fd_pr__pfet_01v8[gm]
+@m.xm42.msky130_fd_pr__pfet_01v8[vth]
+@m.xm43.msky130_fd_pr__pfet_01v8[gm]
+@m.xm43.msky130_fd_pr__pfet_01v8[vth]
+@m.xm44.msky130_fd_pr__nfet_01v8[gm]
+@m.xm44.msky130_fd_pr__nfet_01v8[vth]
+@m.xm45.msky130_fd_pr__nfet_01v8[gm]
+@m.xm45.msky130_fd_pr__nfet_01v8[vth]
+@m.xm46.msky130_fd_pr__nfet_01v8[gm]
+@m.xm46.msky130_fd_pr__nfet_01v8[vth]
+@m.xm47.msky130_fd_pr__nfet_01v8[gm]
+@m.xm47.msky130_fd_pr__nfet_01v8[vth]
+@m.xm48.msky130_fd_pr__nfet_01v8[gm]
+@m.xm48.msky130_fd_pr__nfet_01v8[vth]
+@m.xm49.msky130_fd_pr__nfet_01v8[gm]
+@m.xm49.msky130_fd_pr__nfet_01v8[vth]
+@m.xm52.msky130_fd_pr__pfet_01v8[gm]
+@m.xm52.msky130_fd_pr__pfet_01v8[vth]
+@m.xm52.msky130_fd_pr__pfet_01v8[gds]
+@m.xm63.msky130_fd_pr__pfet_01v8[gm]
+@m.xm63.msky130_fd_pr__pfet_01v8[vth]
+@m.xm63.msky130_fd_pr__pfet_01v8[gds]


* .ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.238 1.242 0.0001
  * dc VDD 0 1.8 0.9
  * dc temp -40 120 10 VDD 0 4.0 0.2
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  * tran 10n 60u
  * tran 100p 2000n
  * tran 1p 3n
  * tran 0.1ns 30us
  ac dec 40 1 10T
  remzerovec
  write tb_opamp_full_5.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc


"}
C {lab_wire.sym} 6960 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 6660 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 7410 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 6830 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6390 -1540 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 5060 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 6660 -3000 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 7410 -3000 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 5150 -3470 0 1 {name=p29 sig_type=std_logic lab=V1}
C {lab_pin.sym} 5930 -3470 0 1 {name=p30 sig_type=std_logic lab=V2}
C {lab_pin.sym} 9410 -1550 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 9250 -1730 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 8490 -1730 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 8940 -1810 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 9020 -1460 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 11150 -2100 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 11120 -2540 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 8740 -3430 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 6830 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3350 0 1 {name=M1
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3350 0 1 {name=M2
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3560 0 1 {name=M3
W=0.81
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3560 0 1 {name=M4
W=3.1
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3620 -3770 0 0 {name=l1 lab=VDD}
C {lab_pin.sym} 4320 -3560 0 1 {name=p1 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 3540 -3350 0 1 {name=p2 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 4400 -3350 0 1 {name=p3 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 3420 -3470 0 1 {name=p4 sig_type=std_logic lab=V3}
C {lab_pin.sym} 4200 -3470 0 1 {name=p5 sig_type=std_logic lab=V4}
C {devices/ngspice_get_value.sym} 3310 -3560 0 1 {name=r5 node=v(@m.xm3.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3310 -3390 0 1 {name=r6 node=v(@m.xm1.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3550 0 1 {name=r3 node=v(@m.xm4.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3380 0 1 {name=r4 node=v(@m.xm2.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -3450 0 1 {name=M5
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3350 0 1 {name=M6
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3560 0 1 {name=M43
W=3.2
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 1950 -3770 0 0 {name=l6 lab=VDD}
C {lab_pin.sym} 2650 -3560 0 1 {name=p6 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 1870 -3450 0 1 {name=p7 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2730 -3350 0 1 {name=p8 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2530 -3470 0 1 {name=p12 sig_type=std_logic lab=V5}
C {devices/ngspice_get_value.sym} 1640 -3490 0 1 {name=r2 node=v(@m.xm5.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3550 0 1 {name=r7 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3380 0 1 {name=r8 node=v(@m.xm6.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 6820 -3760 0 1 {name=p11 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 6900 -3550 0 1 {name=p49 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 7040 -3760 0 1 {name=p50 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 7120 -3550 0 1 {name=p51 sig_type=std_logic lab=Vb4}
C {devices/ngspice_get_value.sym} 5050 -3560 0 1 {name=r1 node=v(@m.xm23.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5050 -3390 0 1 {name=r9 node=v(@m.xm21.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3550 0 1 {name=r14 node=v(@m.xm24.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3380 0 1 {name=r15 node=v(@m.xm22.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 7250 -3760 0 1 {name=p54 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 7330 -3550 0 1 {name=p55 sig_type=std_logic lab=Vb2}
C {devices/ngspice_get_value.sym} 6900 -1890 2 0 {name=r17 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6709.776713144086 -3150 2 1 {name=r16 node=v(@m.xm13.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 10320 -2100 0 0 {name=p14 sig_type=std_logic lab=V_4}
C {lab_wire.sym} 10350 -2540 0 0 {name=p56 sig_type=std_logic lab=V_3}
C {devices/ngspice_get_value.sym} 6709.776713144086 -2730 2 1 {name=r18 node=v(@m.xm11.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6709.776713144086 -2430 0 0 {name=r19 node=v(@m.xm9.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 860 -2550 0 0 {name=l9 lab=VDD}
C {devices/gnd.sym} 860 -2410 0 0 {name=l10 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 2420 -2270 0 0 {name=M42
W=1
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 2440 -2350 0 0 {name=l41 lab=VDD}
C {devices/gnd.sym} 2440 -1910 0 0 {name=l42 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1730 -3080 0 0 {name=M44
W=1
L=0.5
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1750 -2990 0 1 {name=l43 lab=GND}
C {lab_wire.sym} 2610 -2000 0 1 {name=p60 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 1640 -3080 0 0 {name=p61 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 2510 -3070 0 0 {name=M45
W=1
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2980 0 1 {name=l7 lab=GND}
C {lab_wire.sym} 2420 -3070 0 0 {name=p62 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 6940 -3010 0 0 {name=M50
W=1
L=0.5
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6860 -3010 0 0 {name=p67 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 5040 -2370 0 0 {name=M51
W=1
L=0.5
nf=1
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8430 -1390 0 0 {name=M53
W=1
L=0.5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8340 -1390 0 0 {name=p70 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 10340 -2590 0 0 {name=p72 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 11130 -2590 0 1 {name=p73 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 5260 -2070 0 1 {name=p75 sig_type=std_logic lab=VGS9}
C {sky130_fd_pr/nfet_01v8.sym} 10420 -2050 0 0 {name=M54
W=1
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11050 -2050 0 1 {name=M55
W=1
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10420 -2590 0 0 {name=M56
W=1
L=0.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11050 -2590 0 1 {name=M57
W=1
L=0.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1220 -2480 0 0 {name=M58
W=10
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1240 -1730 0 1 {name=R20
L=32
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/vdd.sym} 1620 -2210 2 0 {name=l18 lab=VDD}
C {devices/gnd.sym} 1620 -2330 2 0 {name=l44 lab=GND
W=4}
C {devices/gnd.sym} 1920 -1880 1 0 {name=l45 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1940 -1880 0 0 {name=R21
L=16
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 1920 -2270 0 0 {name=M59
W=1
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 1940 -1990 0 1 {name=p76 sig_type=std_logic lab=V_CUR_REF_REG}
C {lab_wire.sym} 1340 -2290 0 1 {name=p77 sig_type=std_logic lab=V_BGR_REF}
C {lab_wire.sym} 2020 -660 0 1 {name=p78 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 3400 -3080 0 0 {name=M46
W=1
L=0.5
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3420 -2990 0 1 {name=l2 lab=GND}
C {lab_wire.sym} 3310 -3080 0 0 {name=p63 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 4180 -3070 0 0 {name=M47
W=1
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4200 -2980 0 1 {name=l5 lab=GND}
C {lab_wire.sym} 4090 -3070 0 0 {name=p64 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 5130 -3080 0 0 {name=M48
W=1
L=0.5
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5150 -2990 0 1 {name=l8 lab=GND}
C {lab_wire.sym} 5040 -3080 0 0 {name=p65 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 5910 -3070 0 0 {name=M49
W=1
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5930 -2980 0 1 {name=l17 lab=GND}
C {lab_wire.sym} 5820 -3070 0 0 {name=p66 sig_type=std_logic lab=nfet_gate_10uA}
C {devices/gnd.sym} 1580 -1590 0 0 {name=l46 lab=GND}
C {devices/gnd.sym} 1260 -1730 3 0 {name=l47 lab=GND}
C {devices/vdd.sym} 1590 -2590 0 0 {name=l48 lab=VDD}
C {BGR_vtop_out.sym} 860 -2480 0 0 {name=x1}
C {opamp_bandgap_2.sym} 1620 -2270 2 1 {name=x2}
C {lab_wire.sym} 1010 -2480 0 1 {name=p81 sig_type=std_logic lab=V_TOP}
C {lab_wire.sym} 10330 -2050 0 0 {name=p85 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 11140 -2050 0 1 {name=p71 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 2310 -2270 0 0 {name=p59 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 4930 -2370 0 0 {name=p74 sig_type=std_logic lab=pfet_gate_10uA}
C {devices/gnd.sym} 9270 -3230 0 0 {name=l57 lab=GND}
C {vdd.sym} 9270 -4230 0 0 {name=l59 lab=VDD}
C {devices/ngspice_get_value.sym} 8239.776713144085 -4100 2 1 {name=r26 node=v(@m.xm39.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8239.776713144085 -3480 0 0 {name=r27 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/nfet_01v8.sym} 2460 -2000 0 1 {name=M20
W=1
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1120 -2530 0 0 {name=C2 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/gnd.sym} 9460 -3400 0 1 {name=l58 lab=GND}
C {devices/gnd.sym} 8030 -3400 0 0 {name=l64 lab=GND}
C {devices/vdd.sym} 860 -1040 0 0 {name=l67 lab=VDD}
C {devices/gnd.sym} 860 -900 0 0 {name=l68 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1220 -970 0 0 {name=M64
W=10
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1240 -220 0 1 {name=R30
L=12.7
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/vdd.sym} 1620 -700 2 0 {name=l71 lab=VDD}
C {devices/gnd.sym} 1620 -820 2 0 {name=l72 lab=GND
W=4}
C {devices/gnd.sym} 1920 -370 1 0 {name=l73 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1940 -370 0 0 {name=R31
L=12
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 1920 -760 0 0 {name=M65
W=1
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 1940 -480 0 1 {name=p95 sig_type=std_logic lab=dvdv}
C {lab_wire.sym} 1340 -780 0 1 {name=p96 sig_type=std_logic lab=asas}
C {lab_wire.sym} 2020 -2170 0 1 {name=p97 sig_type=std_logic lab=adad}
C {devices/gnd.sym} 1580 -80 0 0 {name=l74 lab=GND}
C {devices/gnd.sym} 1260 -220 3 0 {name=l75 lab=GND}
C {devices/vdd.sym} 1590 -1080 0 0 {name=l76 lab=VDD}
C {BGR_vtop_out.sym} 860 -970 0 0 {name=x3}
C {opamp_bandgap_2.sym} 1620 -760 2 1 {name=x4}
C {lab_wire.sym} 1010 -970 0 1 {name=p98 sig_type=std_logic lab=abab}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1120 -1020 0 0 {name=C8 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/ngspice_get_value.sym} 8239.776713144085 -4050 2 1 {name=r24 node=v(@m.xm39.msky130_fd_pr__pfet_01v8[gds])
descr="gds="}
C {sky130_fd_pr/pfet_01v8.sym} 7720 -4010 0 1 {name=M60
W=10
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7720 -4220 0 1 {name=M61
W=1.18
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 7700 -4370 0 0 {name=l49 lab=VDD}
C {lab_pin.sym} 7700 -4120 0 1 {name=p68 sig_type=std_logic lab=hghg}
C {sky130_fd_pr/nfet_01v8.sym} 7680 -3740 0 0 {name=M62
W=3
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 7700 -3650 0 1 {name=l50 lab=GND}
C {lab_wire.sym} 7590 -3740 0 0 {name=p69 sig_type=std_logic lab=VGS9}
C {lab_pin.sym} 7700 -3870 0 1 {name=p58 sig_type=std_logic lab=vzvz}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8030 -3510 0 0 {name=C4 model=cap_mim_m3_1 W=23 L=23 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9460 -3510 0 0 {name=C5 model=cap_mim_m3_1 W=23 L=23 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9100 -3900 3 0 {name=C6 model=cap_mim_m3_1 W=25 L=25 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 8370 -3900 1 1 {name=C7 model=cap_mim_m3_1 W=25 L=25 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_high_po.sym} 8520 -4020 2 0 {name=R29
W=1.19
L=1
model=res_high_po
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8540 -4020 3 0 {name=l53 lab=GND}
C {sky130_fd_pr/res_high_po.sym} 8950 -4020 2 1 {name=R32
W=1.19
L=1
model=res_high_po
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8930 -4020 1 1 {name=l54 lab=GND}
