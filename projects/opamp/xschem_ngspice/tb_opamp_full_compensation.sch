v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 5790 -810 6400 -260 {flags=graph

y2=1.02
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.86



color="5 17"
node="x
y"}
B 2 6490 -810 7100 -260 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.27




color="12 17"
node="v_out_x
v_out_y"}
B 2 6220 -1480 6830 -930 {flags=graph

y2=0.21
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.19





color=6
node=opamp_vin-}
B 2 5790 -190 6400 360 {flags=graph

y2=0.15
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.15



color=7
node="\\"x y -\\""}
B 2 6490 -190 7100 360 {flags=graph

y2=1.2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-1.2



color=6
node="\\"v_out_x v_out_y -\\""}
B 2 5550 -2240 5900 -1980 {flags=graph

y2=1.2413358
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=1.2378173





color=6
node=opamp_vin-}
B 2 3570 -3310 3740 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 -\\""}
B 2 3550 -3530 3720 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 @m.xm1.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3200 -3530 3370 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm3.msky130_fd_pr__pfet_01v8[vth] @m.xm1.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3200 -3740 3370 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v3 -\\""}
B 2 3460 -3670 3630 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb4 @m.xm3.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4360 -3530 4530 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 -\\""}
B 2 3940 -3520 4110 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm4.msky130_fd_pr__pfet_01v8[vth] @m.xm2.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 3940 -3690 4110 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v4 -\\""}
B 2 4360 -3680 4530 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb5 @m.xm4.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3190 -3310 3360 -3210 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 4360 -3290 4530 -3200 {flags=graph
y1=0.876
y2=0.896
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb4 @m.xm2.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 3970 -3290 4140 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v4 vb5 - \\""}
B 2 3680 -3850 3850 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 1900 -3410 2070 -3290 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 -\\""}
B 2 1880 -3630 2050 -3540 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 @m.xm5.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2690 -3530 2860 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 -\\""}
B 2 2270 -3520 2440 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm43.msky130_fd_pr__pfet_01v8[vth] @m.xm7.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 2270 -3690 2440 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v5 -\\""}
B 2 2690 -3680 2860 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb7 @m.xm43.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 1520 -3410 1690 -3310 {flags=graph
y1=0.95
y2=0.96
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb6 - \\""}
B 2 2690 -3290 2860 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb6 @m.xm6.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 2300 -3290 2470 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v5 vb7 - \\""}
B 2 2010 -3850 2180 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 5310 -3310 5480 -3190 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 -\\""}
B 2 5290 -3530 5460 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v1 vb2 @m.xm21.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4940 -3530 5110 -3440 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm23.msky130_fd_pr__pfet_01v8[vth] @m.xm21.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 4940 -3740 5110 -3650 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v1 - \\""}
B 2 5200 -3670 5370 -3580 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb2 @m.xm23.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 6100 -3530 6270 -3410 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 -\\""}
B 2 5680 -3520 5850 -3430 {flags=graph
y1=0.884
y2=0.904
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm24.msky130_fd_pr__pfet_01v8[vth] @m.xm22.msky130_fd_pr__pfet_01v8[vth] -\\""}
B 2 5680 -3690 5850 -3600 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vdd v2 -\\""}
B 2 6100 -3680 6270 -3590 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vdd vb3 @m.xm24.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 4930 -3310 5100 -3210 {flags=graph
y1=0.948
y2=0.958
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v3 vb4 - \\""}
B 2 6100 -3290 6270 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 @m.xm22.msky130_fd_pr__pfet_01v8[vth] + - \\""}
B 2 5710 -3290 5880 -3200 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"v2 vb2 - \\""}
B 2 5420 -3850 5590 -3760 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vdd}
B 2 7450 -3820 7980 -3440 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.86



color="5 17"
node="x
y"}
B 2 2460 -2920 2990 -2540 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=1
























y1=0.78



color="5 17"
node="x
y"}
B 2 8070 -2170 8240 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"@m.xm20.msky130_fd_pr__nfet_01v8[vth] @m.xm19.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 7690 -2020 7860 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vs20 v_p - \\""}
B 2 7500 -2020 7670 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p -\\""}
B 2 7880 -2020 8050 -1930 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 v_p @m.xm19.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7690 -2170 7860 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vs20 - \\""}
B 2 7500 -2170 7670 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 -\\""}
B 2 7880 -2170 8050 -2080 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vb1 vs20 @m.xm20.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 7500 -2340 7670 -2240 {flags=graph
y1=0.88
y2=0.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"y vd2 @m.xm10.msky130_fd_pr__nfet_01v8[vth] + -\\""}
B 2 12260 -2520 12790 -2140 {flags=graph

y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.00047




color="6 7 11"
node="y
\\"v_1 y - y v_2 - - 2 /\\"
\\"v_tot\\""}
B 2 11670 -2950 12200 -2570 {flags=graph

y2=0.66
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.61




color=6
node="\\"v_1 y -\\""}
B 2 11670 -2090 12200 -1710 {flags=graph

y2=0.95
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.94





color=6
node=v_tot}
B 2 6300 -3090 6590 -2910 {flags=graph

y2=1.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.9



color="5 17"
node="x
y"}
B 2 6240 -2720 6410 -2600 {flags=graph
y1=1.17
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 vb4 -\\""
y2=1.2}
B 2 6050 -2720 6220 -2600 {flags=graph
y1=0.3
y2=0.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 x -\\""}
B 2 6430 -2720 6620 -2600 {flags=graph
y1=0.29
y2=0.31
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vd7 vb4 @m.xm11.msky130_fd_pr__pfet_01v8[vth] + -\\""}
B 2 6240 -2340 6410 -2190 {flags=graph
y1=0.97
y2=0.99
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 vd1 -\\""}
B 2 6050 -2340 6220 -2190 {flags=graph
y1=0.23218228
y2=0.39346228
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"x vd1 - \\""}
B 2 6430 -2340 6600 -2190 {flags=graph
y1=0.16
y2=0.18
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"vb1 @m.xm9.msky130_fd_pr__nfet_01v8[vth] - vd1 -\\""}
B 2 6240 -2100 6410 -1950 {flags=graph
y1=0.94516091
y2=0.94843771
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"opamp_vin- v_p -\\""}
B 2 6050 -2100 6220 -1950 {flags=graph
y1=0.3
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node="\\"vd1 v_p - \\""}
B 2 6430 -2100 6600 -1950 {flags=graph
y1=0.16
y2=0.18
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1

color=6
node="\\"opamp_vin- @m.xm7.msky130_fd_pr__nfet_01v8[vth] - v_p -\\""}
B 2 6050 -2530 6220 -2390 {flags=graph
y1=0.52
y2=0.54
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=vd1}
B 2 1460 -1920 1830 -1670 {flags=graph

y2=1.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=1e-05





color=4
node=i(@m.xm59.msky130_fd_pr__pfet_01v8[id])}
B 2 1820 -2920 2190 -2670 {flags=graph

y2=5.1e-05
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=5e-05





color=7
node=i(@m.xm44.msky130_fd_pr__nfet_01v8[id])}
B 2 12850 -2520 13380 -2140 {flags=graph

y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.67




color="6 7 11 17 9"
node="\\"v_1 y -\\"
\\"y v_2 -\\"
y
\\"y v_1 -\\"


\\"v_1 y - y v_2 - +\\""}
B 2 9800 -2330 10120 -2120 {flags=graph

y2=-2.3e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-3e-06






color="7 6"
node="i(@r.xr11.x0.rend1[i])
i(@r.xr11.x0.rend2[i])"}
B 2 9800 -2630 10120 -2420 {flags=graph

y2=2.6e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=1.9e-06






color="7 6"
node="i(@r.xr10.x0.rend1[i])
i(@r.xr10.x0.rend2[i])"}
B 2 9800 -2040 10120 -1800 {flags=graph

y2=0.75
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.63




color="6 7"
node="\\"v_1 y -\\"
\\"y v_2 -\\""}
B 2 12260 -2950 12790 -2570 {flags=graph

y2=0.64235637
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.61675637




color=7
node="\\"y v_2 -\\""}
B 2 10790 -2390 11010 -2240 {flags=graph

y2=0.69
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.59




color="6 7"
node="\\"v_1 y -\\"
\\"y v_2 -\\""}
B 2 12260 -2090 12790 -1710 {flags=graph

y2=1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=0.0014




color="6 7 11 15 17"
node="y
\\"v_1 y - y v_2 - -\\"
\\"v_1 y - y v_2 - - 2 /\\"
\\"y v_1 y - y v_2 - - 2 / +\\"
\\"v_tot\\""}
B 2 770 -2280 1140 -2030 {flags=graph

y2=0.906
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.896






color=4
node=v_ref}
B 2 770 -1990 1140 -1740 {flags=graph

y2=5.4e-06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=5.3e-06





color=4
node=i(@m.xm58.msky130_fd_pr__pfet_01v8[id])}
B 2 780 -2870 1150 -2620 {flags=graph

y2=0.85796892
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.85284892






color=4
node=v_top}
B 2 7000 -1390 7300 -1180 {flags=graph
y1=0.26
y2=0.27
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0
linewidth_mult=1


color=6
node=v_p}
B 2 11670 -2520 12200 -2140 {flags=graph

y2=0.06
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.012




color=6
node="\\"v_1 y - y v_2 - - \\""}
B 2 11170 -2440 11700 -2060 {flags=graph

y2=0.021
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=4
























y1=-0.015




color=6
node="\\"0.5 v_1 y - * 0.5 y v_2 - * -\\""}
B 2 4110 -1390 4460 -1130 {flags=graph

y2=0.2012
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.1988





color="6 7"
node="opamp_vin-
opamp_vin+"}
B 2 4110 -1090 4460 -830 {flags=graph

y2=1.2318
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=1.2297







color="6 7"
node="v_cm+
v_cm-"}
B 2 4570 -1390 4920 -1130 {flags=graph

y2=0.002
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.002





color=6
node="\\"opamp_vin- opamp_vin+ - \\""}
B 2 4570 -1090 4920 -830 {flags=graph

y2=0.0022
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=-0.0022







color=6
node="\\"v_cm+ v_cm- - \\""}
B 2 4110 -780 4460 -520 {flags=graph

y2=0.65
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=0.64








color="6 7"
node="v4_p1
v4_p2"
autoload=0}
B 2 1850 -710 2200 -450 {flags=graph

y2=1.4087516
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=1.4087383







color=6
node=vg1}
B 2 3120 -710 3470 -450 {flags=graph

y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=1.4







color="6 7"
node="vg1
vg2"}
B 2 7190 -190 7800 360 {flags=graph

y2=17
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.9043733e-06
x2=3.4361473e-06
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0











linewidth_mult=2
























y1=5.3



color=6
node="\\"-1 v_out_x v_out_y - x y - / *\\""}
T {VDS3} 3140 -3710 0 0 0.3 0.3 {}
T {VGS3-VTH3} 3640 -3640 0 0 0.3 0.3 {}
T {VTH3-VTH1} 3080 -3490 0 0 0.3 0.3 {}
T {VGS1-VTH1} 3590 -3430 0 0 0.3 0.3 {}
T {VDS1} 3130 -3270 0 0 0.3 0.3 {}
T {VDS4} 3880 -3650 0 0 0.3 0.3 {}
T {VGS4-VTH4} 4550 -3650 0 0 0.3 0.3 {}
T {VTH4-VTH2} 3820 -3480 0 0 0.3 0.3 {}
T {VGS2-VTH2} 4540 -3250 0 0 0.3 0.3 {}
T {VDS2} 4030 -3190 0 0 0.3 0.3 {}
T {Vb2} 3640 -3180 0 0 0.3 0.3 {}
T {Vb5} 4540 -3480 0 0 0.3 0.3 {}
T {VGS5-VTH5} 1920 -3530 0 0 0.3 0.3 {}
T {VDS6} 1460 -3370 0 0 0.3 0.3 {}
T {VDS43} 2210 -3650 0 0 0.3 0.3 {}
T {VGS43-VTH43} 2880 -3650 0 0 0.3 0.3 {}
T {VTH43-VTH6} 2150 -3480 0 0 0.3 0.3 {}
T {VGS6-VTH6} 2870 -3250 0 0 0.3 0.3 {}
T {VDS2} 2360 -3190 0 0 0.3 0.3 {}
T {Vb6} 1970 -3280 0 0 0.3 0.3 {}
T {Vb7} 2870 -3480 0 0 0.3 0.3 {}
T {VDS23} 4880 -3710 0 0 0.3 0.3 {}
T {VGS23-VTH23} 5380 -3640 0 0 0.3 0.3 {}
T {VTH23-VTH21} 4820 -3490 0 0 0.3 0.3 {}
T {VGS21-VTH21} 5330 -3430 0 0 0.3 0.3 {}
T {VDS21} 4870 -3270 0 0 0.3 0.3 {}
T {VDS24} 5620 -3650 0 0 0.3 0.3 {}
T {VGS24-VTH24} 6290 -3650 0 0 0.3 0.3 {}
T {VTH24-VTH22} 5560 -3480 0 0 0.3 0.3 {}
T {VGS22-VTH22} 6280 -3250 0 0 0.3 0.3 {}
T {VDS2} 5770 -3190 0 0 0.3 0.3 {}
T {Vb2} 5380 -3180 0 0 0.3 0.3 {}
T {Vb3} 6280 -3480 0 0 0.3 0.3 {}
T {VTH20-VTH19} 8100 -2070 0 0 0.3 0.3 {}
T {VDS19} 7750 -1920 0 0 0.3 0.3 {}
T {VGS19} 7560 -1920 0 0 0.3 0.3 {}
T {VGS19-VTH19} 7910 -1920 0 0 0.3 0.3 {}
T {VDS20} 7750 -2070 0 0 0.3 0.3 {}
T {VGS20} 7560 -2070 0 0 0.3 0.3 {}
T {VGS20-VTH20} 7910 -2070 0 0 0.3 0.3 {}
T {VGS10-VTH10} 7540 -2230 0 0 0.3 0.3 {}
T {VGS11} 6300 -2590 0 0 0.3 0.3 {}
T {VDS11} 6110 -2590 0 0 0.3 0.3 {}
T {VGS11-VTH11} 6470 -2590 0 0 0.3 0.3 {}
T {VGS9} 6300 -2180 0 0 0.3 0.3 {}
T {VDS9} 6110 -2180 0 0 0.3 0.3 {}
T {VGS9-VTH9} 6470 -2180 0 0 0.3 0.3 {}
T {VGS7} 6300 -1940 0 0 0.3 0.3 {}
T {VDS7} 6110 -1940 0 0 0.3 0.3 {}
T {VGS7-VTH7} 6470 -1940 0 0 0.3 0.3 {}
T {N 50uA} 1870 -3100 0 0 1 1 {}
T {N 50uA} 2640 -3100 0 0 1 1 {}
T {P 100uA} 5130 -2420 0 0 1 1 {}
T {P 20uA} 7060 -3050 0 0 1 1 {}
T {N 2uA} 9450 -3880 0 0 1 1 {}
T {N 20uA} 8550 -1410 0 0 1 1 {}
T {N 30uA} 10150 -2010 0 0 1 1 {}
T {P 30uA} 10170 -2700 0 0 1 1 {}
T {P 30uA} 11300 -2700 0 1 1 1 {}
T {N 30uA} 11320 -2010 0 1 1 1 {}
T {N 50uA} 3540 -3100 0 0 1 1 {}
T {N 50uA} 4310 -3100 0 0 1 1 {}
T {N 50uA} 5270 -3100 0 0 1 1 {}
T {N 50uA} 6040 -3100 0 0 1 1 {}
N 6660 -1770 6660 -1680 {lab=V_p}
N 6660 -1680 7410 -1680 {lab=V_p}
N 7410 -1770 7410 -1680 {lab=V_p}
N 6660 -2380 6660 -1830 {lab=VD1}
N 7410 -2380 7410 -1830 {lab=VD2}
N 6700 -2410 7370 -2410 {lab=Vb1}
N 6660 -2740 6660 -2440 {lab=X}
N 7410 -2740 7410 -2440 {lab=Y}
N 6660 -3160 6660 -2800 {lab=VD7}
N 7410 -3160 7410 -2800 {lab=VD6}
N 6700 -2770 7370 -2770 {lab=Vb6}
N 7410 -2770 7480 -2770 {lab=VD6}
N 7480 -2840 7480 -2770 {lab=VD6}
N 7410 -2840 7480 -2840 {lab=VD6}
N 6590 -2770 6660 -2770 {lab=VD7}
N 6590 -2840 6590 -2770 {lab=VD7}
N 6590 -2840 6660 -2840 {lab=VD7}
N 6660 -3340 6660 -3220 {lab=VDD}
N 7410 -3340 7410 -3220 {lab=VDD}
N 6700 -3190 7370 -3190 {lab=Vb7}
N 7410 -3190 7480 -3190 {lab=VDD}
N 7480 -3260 7480 -3190 {lab=VDD}
N 7410 -3260 7480 -3260 {lab=VDD}
N 6590 -3190 6660 -3190 {lab=VDD}
N 6590 -3260 6590 -3190 {lab=VDD}
N 6590 -3260 6660 -3260 {lab=VDD}
N 6660 -3340 7410 -3340 {lab=VDD}
N 6610 -2410 6660 -2410 {lab=GND}
N 6610 -2410 6610 -2350 {lab=GND}
N 6610 -2350 7470 -2350 {lab=GND}
N 7470 -2410 7470 -2350 {lab=GND}
N 7410 -2410 7470 -2410 {lab=GND}
N 6840 -3400 6840 -3340 {lab=VDD}
N 7110 -1800 7410 -1800 {lab=GND}
N 6660 -1800 7110 -1800 {lab=GND}
N 6960 -1680 6960 -1570 {lab=V_p}
N 7110 -1800 7110 -1540 {lab=GND}
N 6960 -1540 7110 -1540 {lab=GND}
N 6960 -1510 6960 -1420 {lab=GND}
N 6960 -1460 7110 -1460 {lab=GND}
N 7110 -1540 7110 -1460 {lab=GND}
N 7450 -1800 7540 -1800 {lab=V_cm+}
N 5060 -1680 5060 -1570 {lab=V_p_mir}
N 4980 -1540 5060 -1540 {lab=GND}
N 5060 -1510 5060 -1420 {lab=GND}
N 4980 -1460 5060 -1460 {lab=GND}
N 4980 -1540 4980 -1460 {lab=GND}
N 5100 -1540 6920 -1540 {lab=VGS9}
N 5060 -2460 5060 -2400 {lab=VDD}
N 5140 -1800 5230 -1800 {lab=GND}
N 4900 -1800 5140 -1800 {lab=GND}
N 4900 -1770 4900 -1680 {lab=V_p_mir}
N 4900 -1680 5230 -1680 {lab=V_p_mir}
N 5230 -1770 5230 -1680 {lab=V_p_mir}
N 4980 -1800 4980 -1540 {lab=GND}
N 4900 -1950 4900 -1830 {lab=VGS9}
N 4900 -1950 5230 -1950 {lab=VGS9}
N 5230 -1950 5230 -1830 {lab=VGS9}
N 5060 -2150 5060 -1950 {lab=VGS9}
N 5270 -1800 5340 -1800 {lab=V_cm-}
N 4790 -1800 4860 -1800 {lab=V_cm+}
N 5060 -2070 5460 -2070 {lab=VGS9}
N 5460 -2070 5460 -1540 {lab=VGS9}
N 6960 -2060 6960 -1980 {lab=Vb1}
N 6960 -1950 7110 -1950 {lab=GND}
N 6960 -1920 6960 -1680 {lab=V_p}
N 6960 -2410 6960 -2120 {lab=Vb1}
N 6830 -1950 6920 -1950 {lab=Vb1}
N 6830 -2210 6830 -1950 {lab=Vb1}
N 6830 -2210 6960 -2210 {lab=Vb1}
N 6960 -2980 6960 -2410 {lab=Vb1}
N 6960 -3340 6960 -3040 {lab=VDD}
N 5150 -3320 5150 -3200 {lab=Vb2}
N 5930 -3320 5930 -3200 {lab=Vb3}
N 5150 -3530 5150 -3380 {lab=V1}
N 5930 -3530 5930 -3380 {lab=V2}
N 5860 -3350 5930 -3350 {lab=V2}
N 5860 -3420 5860 -3350 {lab=V2}
N 5860 -3420 5930 -3420 {lab=V2}
N 5080 -3350 5150 -3350 {lab=V1}
N 5080 -3420 5080 -3350 {lab=V1}
N 5080 -3420 5150 -3420 {lab=V1}
N 5150 -3710 5150 -3590 {lab=VDD}
N 5930 -3710 5930 -3590 {lab=VDD}
N 5860 -3560 5930 -3560 {lab=VDD}
N 5860 -3630 5860 -3560 {lab=VDD}
N 5860 -3630 5930 -3630 {lab=VDD}
N 5080 -3560 5150 -3560 {lab=VDD}
N 5080 -3630 5080 -3560 {lab=VDD}
N 5080 -3630 5150 -3630 {lab=VDD}
N 5350 -3770 5350 -3710 {lab=VDD}
N 5150 -3710 5930 -3710 {lab=VDD}
N 5190 -3560 5270 -3560 {lab=Vb2}
N 5190 -3350 5270 -3350 {lab=Vb2}
N 5970 -3560 6050 -3560 {lab=Vb3}
N 6050 -3560 6050 -3250 {lab=Vb3}
N 5930 -3250 6050 -3250 {lab=Vb3}
N 5270 -3560 5270 -3250 {lab=Vb2}
N 5150 -3250 5270 -3250 {lab=Vb2}
N 5970 -3350 6130 -3350 {lab=Vb2}
N 10440 -2230 10440 -2180 {lab=VDD}
N 10440 -2020 10440 -1960 {lab=GND}
N 10440 -2120 10440 -2080 {lab=V_4}
N 10440 -2460 10440 -2410 {lab=GND}
N 10440 -2570 10440 -2520 {lab=V_3}
N 10320 -2490 10320 -2150 {lab=X}
N 11070 -2490 11140 -2490 {lab=Y}
N 11140 -2490 11140 -2150 {lab=Y}
N 11070 -2150 11140 -2150 {lab=Y}
N 10200 -2330 10320 -2330 {lab=X}
N 11140 -2330 11260 -2330 {lab=Y}
N 10880 -2540 11030 -2540 {lab=V_1}
N 10880 -2100 11030 -2100 {lab=V_2}
N 10440 -2490 10520 -2490 {lab=VDD}
N 10440 -2650 10520 -2650 {lab=VDD}
N 10440 -2680 10440 -2620 {lab=VDD}
N 10520 -2650 10520 -2490 {lab=VDD}
N 10440 -1990 10520 -1990 {lab=GND}
N 10440 -2150 10520 -2150 {lab=GND}
N 10520 -2150 10520 -1990 {lab=GND}
N 11030 -2230 11030 -2180 {lab=VDD}
N 11030 -2020 11030 -1960 {lab=GND}
N 11030 -2120 11030 -2080 {lab=V_2}
N 11030 -2460 11030 -2410 {lab=GND}
N 11030 -2570 11030 -2520 {lab=V_1}
N 10950 -2490 11030 -2490 {lab=VDD}
N 10950 -2650 11030 -2650 {lab=VDD}
N 11030 -2680 11030 -2620 {lab=VDD}
N 10950 -2650 10950 -2490 {lab=VDD}
N 10950 -1990 11030 -1990 {lab=GND}
N 10950 -2150 11030 -2150 {lab=GND}
N 10950 -2150 10950 -1990 {lab=GND}
N 10740 -2540 10740 -2100 {lab=V_tot}
N 9410 -1730 9410 -1660 {lab=V_err_p}
N 9170 -1730 9410 -1730 {lab=V_err_p}
N 9170 -1730 9170 -1660 {lab=V_err_p}
N 9290 -1780 9290 -1730 {lab=V_err_p}
N 9290 -1890 9290 -1840 {lab=VDD}
N 9410 -1600 9410 -1480 {lab=err_opamp_mir}
N 9170 -1600 9170 -1480 {lab=err_opamp_out}
N 9410 -1420 9410 -1370 {lab=GND}
N 9170 -1370 9410 -1370 {lab=GND}
N 9170 -1420 9170 -1370 {lab=GND}
N 9290 -1370 9290 -1320 {lab=GND}
N 9170 -1630 9410 -1630 {lab=VDD}
N 9210 -1450 9370 -1450 {lab=err_opamp_mir}
N 9130 -1450 9170 -1450 {lab=GND}
N 9130 -1450 9130 -1400 {lab=GND}
N 9130 -1400 9170 -1400 {lab=GND}
N 9410 -1450 9450 -1450 {lab=GND}
N 9450 -1450 9450 -1400 {lab=GND}
N 9410 -1400 9450 -1400 {lab=GND}
N 9310 -1530 9410 -1530 {lab=err_opamp_mir}
N 9310 -1530 9310 -1450 {lab=err_opamp_mir}
N 10740 -2100 10740 -1630 {lab=V_tot}
N 9040 -1630 9130 -1630 {lab=V_ref}
N 7110 -1540 7260 -1540 {lab=GND}
N 7110 -1460 7260 -1460 {lab=GND}
N 7260 -1510 7260 -1460 {lab=GND}
N 7260 -1680 7260 -1570 {lab=V_p}
N 9450 -1630 10740 -1630 {lab=V_tot}
N 11520 -2630 11520 -2570 {lab=V_ref}
N 9290 -1810 9330 -1810 {lab=VDD}
N 9330 -1870 9330 -1810 {lab=VDD}
N 9290 -1870 9330 -1870 {lab=VDD}
N 9330 -1810 9330 -1630 {lab=VDD}
N 8330 -1730 8330 -1660 {lab=V_err_mir_p}
N 8330 -1730 8570 -1730 {lab=V_err_mir_p}
N 8570 -1730 8570 -1660 {lab=V_err_mir_p}
N 8450 -1780 8450 -1730 {lab=V_err_mir_p}
N 8450 -1890 8450 -1840 {lab=VDD}
N 8330 -1630 8570 -1630 {lab=VDD}
N 8610 -1630 8700 -1630 {lab=V_ref}
N 8410 -1810 8450 -1810 {lab=VDD}
N 8410 -1870 8410 -1810 {lab=VDD}
N 8410 -1870 8450 -1870 {lab=VDD}
N 8410 -1810 8410 -1630 {lab=VDD}
N 8490 -1810 9250 -1810 {lab=V_gate}
N 8330 -1600 8330 -1540 {lab=V_gate}
N 8330 -1540 8570 -1540 {lab=V_gate}
N 8570 -1600 8570 -1540 {lab=V_gate}
N 8450 -1540 8450 -1420 {lab=V_gate}
N 8200 -1630 8290 -1630 {lab=V_tot}
N 8450 -1360 8450 -1310 {lab=GND}
N 8890 -1810 8890 -1480 {lab=V_gate}
N 8450 -1480 8890 -1480 {lab=V_gate}
N 7300 -1540 8000 -1540 {lab=err_opamp_out}
N 8000 -1540 8000 -1180 {lab=err_opamp_out}
N 8000 -1180 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9020 -1180 {lab=err_opamp_out}
N 9020 -1550 9170 -1550 {lab=err_opamp_out}
N 7110 -2090 7110 -1800 {lab=GND}
N 7110 -2350 7110 -2090 {lab=GND}
N 8750 -4640 8750 -3970 {lab=V_OUT_X}
N 9860 -4640 9860 -3970 {lab=V_OUT_Y}
N 9860 -4670 9930 -4670 {lab=VDD}
N 9930 -4740 9930 -4670 {lab=VDD}
N 9860 -4740 9930 -4740 {lab=VDD}
N 8680 -4670 8750 -4670 {lab=VDD}
N 8680 -4740 8750 -4740 {lab=VDD}
N 8680 -4740 8680 -4670 {lab=VDD}
N 8750 -4770 8750 -4700 {lab=VDD}
N 9860 -4770 9860 -4700 {lab=VDD}
N 8750 -3910 8750 -3740 {lab=GND}
N 9860 -3910 9860 -3740 {lab=GND}
N 9860 -3870 9930 -3870 {lab=GND}
N 9930 -3940 9930 -3870 {lab=GND}
N 9860 -3940 9930 -3940 {lab=GND}
N 8680 -3870 8750 -3870 {lab=GND}
N 8680 -3940 8750 -3940 {lab=GND}
N 8680 -3940 8680 -3870 {lab=GND}
N 8790 -4670 9170 -4670 {lab=X}
N 9440 -4670 9820 -4670 {lab=Y}
N 8640 -4130 8750 -4130 {lab=V_OUT_X}
N 9860 -4130 9970 -4130 {lab=V_OUT_Y}
N 9730 -4060 9860 -4060 {lab=V_OUT_Y}
N 9310 -3940 9820 -3940 {lab=V_b}
N 9370 -4060 9670 -4060 {lab=V_b}
N 9370 -4060 9370 -3940 {lab=V_b}
N 8750 -4060 8880 -4060 {lab=V_OUT_X}
N 8940 -4060 9250 -4060 {lab=V_b}
N 8790 -3940 9310 -3940 {lab=V_b}
N 9250 -4060 9250 -3940 {lab=V_b}
N 10650 -2100 10820 -2100 {lab=V_tot}
N 10650 -2540 10820 -2540 {lab=V_tot}
N 10440 -2540 10590 -2540 {lab=V_3}
N 10440 -2100 10590 -2100 {lab=V_4}
N 10320 -2490 10400 -2490 {lab=X}
N 10320 -2150 10400 -2150 {lab=X}
N 6490 -1800 6620 -1800 {lab=V_cm-}
N 11030 -2100 11150 -2100 {lab=V_2}
N 11030 -2540 11120 -2540 {lab=V_1}
N 6660 -1680 7410 -1680 {lab=V_p}
N 6140 -1800 6490 -1800 {lab=V_cm-}
N 5340 -1800 6140 -1800 {lab=V_cm-}
N 4790 -1900 6140 -1900 {lab=V_cm+}
N 4790 -1900 4790 -1800 {lab=V_cm+}
N 7540 -1900 7540 -1800 {lab=V_cm+}
N 6140 -1900 7540 -1900 {lab=V_cm+}
N 6490 -1740 6490 -1670 {lab=opamp_Vin-}
N 7540 -1740 7540 -1670 {lab=opamp_Vin+}
N 5060 -2340 5060 -2150 {lab=VGS9}
N 3420 -3320 3420 -3200 {lab=Vb4}
N 4200 -3320 4200 -3200 {lab=Vb5}
N 3420 -3530 3420 -3380 {lab=V3}
N 4200 -3530 4200 -3380 {lab=V4}
N 4130 -3350 4200 -3350 {lab=V4}
N 4130 -3420 4130 -3350 {lab=V4}
N 4130 -3420 4200 -3420 {lab=V4}
N 3350 -3350 3420 -3350 {lab=V3}
N 3350 -3420 3350 -3350 {lab=V3}
N 3350 -3420 3420 -3420 {lab=V3}
N 3420 -3710 3420 -3590 {lab=VDD}
N 4200 -3710 4200 -3590 {lab=VDD}
N 4130 -3560 4200 -3560 {lab=VDD}
N 4130 -3630 4130 -3560 {lab=VDD}
N 4130 -3630 4200 -3630 {lab=VDD}
N 3350 -3560 3420 -3560 {lab=VDD}
N 3350 -3630 3350 -3560 {lab=VDD}
N 3350 -3630 3420 -3630 {lab=VDD}
N 3620 -3770 3620 -3710 {lab=VDD}
N 3420 -3710 4200 -3710 {lab=VDD}
N 3460 -3560 3540 -3560 {lab=Vb4}
N 3460 -3350 3540 -3350 {lab=Vb4}
N 4240 -3560 4320 -3560 {lab=Vb5}
N 4320 -3560 4320 -3250 {lab=Vb5}
N 4200 -3250 4320 -3250 {lab=Vb5}
N 3540 -3560 3540 -3250 {lab=Vb4}
N 3420 -3250 3540 -3250 {lab=Vb4}
N 4240 -3350 4400 -3350 {lab=Vb4}
N 1750 -3420 1750 -3210 {lab=Vb6}
N 2530 -3320 2530 -3200 {lab=Vb7}
N 2530 -3530 2530 -3380 {lab=V5}
N 2460 -3350 2530 -3350 {lab=V5}
N 2460 -3420 2460 -3350 {lab=V5}
N 2460 -3420 2530 -3420 {lab=V5}
N 1680 -3450 1750 -3450 {lab=VDD}
N 1680 -3520 1680 -3450 {lab=VDD}
N 1680 -3520 1750 -3520 {lab=VDD}
N 2530 -3710 2530 -3590 {lab=VDD}
N 2460 -3560 2530 -3560 {lab=VDD}
N 2460 -3630 2460 -3560 {lab=VDD}
N 2460 -3630 2530 -3630 {lab=VDD}
N 1950 -3770 1950 -3710 {lab=VDD}
N 1750 -3710 2530 -3710 {lab=VDD}
N 1790 -3450 1870 -3450 {lab=Vb6}
N 2570 -3560 2650 -3560 {lab=Vb7}
N 2650 -3560 2650 -3250 {lab=Vb7}
N 2530 -3250 2650 -3250 {lab=Vb7}
N 1750 -3350 1870 -3350 {lab=Vb6}
N 2570 -3350 2730 -3350 {lab=Vb6}
N 1870 -3450 1870 -3350 {lab=Vb6}
N 1750 -3710 1750 -3480 {lab=VDD}
N 6960 -2120 6960 -2060 {lab=Vb1}
N 10320 -2100 10440 -2100 {lab=V_4}
N 10350 -2540 10440 -2540 {lab=V_3}
N 1030 -2480 1200 -2480 {lab=V_TOP}
N 2280 -2330 2280 -2280 {lab=VDD}
N 2280 -2250 2330 -2250 {lab=VDD}
N 2330 -2310 2330 -2250 {lab=VDD}
N 2280 -2310 2330 -2310 {lab=VDD}
N 2150 -2250 2240 -2250 {lab=pfet_gate_10uA}
N 2280 -1950 2280 -1890 {lab=GND}
N 2230 -1920 2280 -1920 {lab=GND}
N 2230 -1980 2230 -1920 {lab=GND}
N 2230 -1980 2280 -1980 {lab=GND}
N 2280 -2220 2280 -2010 {lab=nfet_gate_10uA}
N 1750 -3050 1750 -2990 {lab=GND}
N 1750 -3020 1800 -3020 {lab=GND}
N 1800 -3080 1800 -3020 {lab=GND}
N 1750 -3080 1800 -3080 {lab=GND}
N 1750 -3210 1750 -3110 {lab=Vb6}
N 2350 -2050 2350 -1980 {lab=nfet_gate_10uA}
N 2280 -2050 2350 -2050 {lab=nfet_gate_10uA}
N 2320 -1980 2450 -1980 {lab=nfet_gate_10uA}
N 1640 -3080 1710 -3080 {lab=nfet_gate_10uA}
N 2530 -3040 2530 -2980 {lab=GND}
N 2530 -3010 2580 -3010 {lab=GND}
N 2580 -3070 2580 -3010 {lab=GND}
N 2530 -3070 2580 -3070 {lab=GND}
N 2530 -3200 2530 -3100 {lab=Vb7}
N 2420 -3070 2490 -3070 {lab=nfet_gate_10uA}
N 3420 -3200 3420 -3100 {lab=Vb4}
N 4200 -3200 4200 -3100 {lab=Vb5}
N 5150 -3200 5150 -3100 {lab=Vb2}
N 5930 -3200 5930 -3100 {lab=Vb3}
N 6960 -3010 7010 -3010 {lab=VDD}
N 7010 -3070 7010 -3010 {lab=VDD}
N 6960 -3070 7010 -3070 {lab=VDD}
N 6860 -3010 6920 -3010 {lab=pfet_gate_10uA}
N 5060 -2370 5110 -2370 {lab=VDD}
N 5110 -2430 5110 -2370 {lab=VDD}
N 5060 -2430 5110 -2430 {lab=VDD}
N 4930 -2370 5020 -2370 {lab=pfet_gate_10uA}
N 8450 -1330 8500 -1330 {lab=GND}
N 8500 -1390 8500 -1330 {lab=GND}
N 8450 -1390 8500 -1390 {lab=GND}
N 8340 -1390 8410 -1390 {lab=nfet_gate_10uA}
N 10490 -2050 10490 -1990 {lab=GND}
N 10440 -2050 10490 -2050 {lab=GND}
N 10330 -2050 10400 -2050 {lab=nfet_gate_10uA}
N 10440 -2590 10490 -2590 {lab=VDD}
N 10490 -2650 10490 -2590 {lab=VDD}
N 10340 -2590 10400 -2590 {lab=pfet_gate_10uA}
N 10980 -2590 11030 -2590 {lab=VDD}
N 10980 -2650 10980 -2590 {lab=VDD}
N 11070 -2590 11130 -2590 {lab=pfet_gate_10uA}
N 10980 -2050 10980 -1990 {lab=GND}
N 10980 -2050 11030 -2050 {lab=GND}
N 11070 -2050 11140 -2050 {lab=nfet_gate_10uA}
N 1240 -1700 1240 -1590 {lab=GND}
N 1240 -2590 1240 -2510 {
lab=VDD}
N 1240 -2480 1280 -2480 {lab=VDD}
N 1280 -2550 1280 -2480 {lab=VDD}
N 1240 -2550 1280 -2550 {lab=VDD}
N 1240 -2290 1340 -2290 {lab=V_REF}
N 1240 -2450 1240 -1760 {lab=V_REF}
N 1940 -2270 1980 -2270 {lab=VDD}
N 1980 -2340 1980 -2270 {lab=VDD}
N 1940 -2340 1980 -2340 {lab=VDD}
N 1690 -2270 1900 -2270 {lab=pfet_gate_10uA}
N 1470 -2250 1560 -2250 {lab=V_CUR_REF_REG}
N 1470 -2250 1470 -1990 {lab=V_CUR_REF_REG}
N 1470 -1990 1940 -1990 {lab=V_CUR_REF_REG}
N 1940 -2240 1940 -1910 {lab=V_CUR_REF_REG}
N 1340 -2290 1560 -2290 {lab=V_REF}
N 1240 -2590 1940 -2590 {lab=VDD}
N 1940 -2590 1940 -2300 {lab=VDD}
N 1240 -1590 1940 -1590 {lab=GND}
N 1940 -1850 1940 -1590 {lab=GND}
N 1840 -2270 1840 -2170 {lab=pfet_gate_10uA}
N 1840 -2170 2020 -2170 {lab=pfet_gate_10uA}
N 3420 -3050 3420 -2990 {lab=GND}
N 3420 -3020 3470 -3020 {lab=GND}
N 3470 -3080 3470 -3020 {lab=GND}
N 3420 -3080 3470 -3080 {lab=GND}
N 3310 -3080 3380 -3080 {lab=nfet_gate_10uA}
N 4200 -3040 4200 -2980 {lab=GND}
N 4200 -3010 4250 -3010 {lab=GND}
N 4250 -3070 4250 -3010 {lab=GND}
N 4200 -3070 4250 -3070 {lab=GND}
N 4090 -3070 4160 -3070 {lab=nfet_gate_10uA}
N 5150 -3050 5150 -2990 {lab=GND}
N 5150 -3020 5200 -3020 {lab=GND}
N 5200 -3080 5200 -3020 {lab=GND}
N 5150 -3080 5200 -3080 {lab=GND}
N 5040 -3080 5110 -3080 {lab=nfet_gate_10uA}
N 5930 -3040 5930 -2980 {lab=GND}
N 5930 -3010 5980 -3010 {lab=GND}
N 5980 -3070 5980 -3010 {lab=GND}
N 5930 -3070 5980 -3070 {lab=GND}
N 5820 -3070 5890 -3070 {lab=nfet_gate_10uA}
N 9310 -3940 9310 -3850 {lab=V_b}
N 9220 -3820 9270 -3820 {lab=nfet_gate_10uA}
N 9310 -3820 9360 -3820 {lab=GND}
N 9310 -3790 9310 -3700 {lab=#net1}
N 9220 -3670 9270 -3670 {lab=nfet_gate_10uA}
N 9310 -3670 9360 -3670 {lab=GND}
N 9360 -3820 9360 -3670 {lab=GND}
N 9310 -3640 9310 -3550 {lab=#net2}
N 9220 -3520 9270 -3520 {lab=nfet_gate_10uA}
N 9310 -3520 9360 -3520 {lab=GND}
N 9360 -3670 9360 -3520 {lab=GND}
N 9310 -3490 9310 -3400 {lab=#net3}
N 9220 -3370 9270 -3370 {lab=nfet_gate_10uA}
N 9310 -3370 9360 -3370 {lab=GND}
N 9360 -3520 9360 -3370 {lab=GND}
N 9310 -3340 9310 -3250 {lab=#net4}
N 9220 -3220 9270 -3220 {lab=nfet_gate_10uA}
N 9310 -3220 9360 -3220 {lab=GND}
N 9360 -3370 9360 -3220 {lab=GND}
N 9220 -3820 9220 -3670 {lab=nfet_gate_10uA}
N 9220 -3670 9220 -3520 {lab=nfet_gate_10uA}
N 9220 -3520 9220 -3370 {lab=nfet_gate_10uA}
N 9220 -3370 9220 -3220 {lab=nfet_gate_10uA}
N 9310 -3190 9310 -3100 {lab=GND}
N 9360 -3220 9360 -3150 {lab=GND}
N 9310 -3150 9360 -3150 {lab=GND}
N 1690 -120 1690 -10 {lab=GND}
N 1690 -230 1770 -230 {lab=v_mir_1}
N 1770 -230 1770 -150 {lab=v_mir_1}
N 1730 -150 1770 -150 {lab=v_mir_1}
N 1640 -150 1690 -150 {lab=GND}
N 1770 -150 1910 -150 {lab=v_mir_1}
N 1640 -150 1640 -90 {lab=GND}
N 1640 -90 1690 -90 {lab=GND}
N 2510 -150 2560 -150 {lab=GND}
N 2560 -150 2560 -90 {lab=GND}
N 2510 -90 2560 -90 {lab=GND}
N 1970 -150 2470 -150 {lab=v_mir_gate_1}
N 2510 -640 2510 -180 {lab=V_cm+}
N 2510 -960 2510 -860 {lab=VDD}
N 2150 -410 2150 -310 {lab=opamp_Vin-}
N 2150 -250 2150 -150 {lab=v_mir_gate_1}
N 1690 -480 1690 -350 {lab=vg1}
N 1690 -290 1690 -180 {lab=v_mir_1}
N 1730 -320 1940 -320 {lab=vg1}
N 1940 -320 1940 -190 {lab=vg1}
N 1690 -400 1770 -400 {lab=vg1}
N 1770 -400 1770 -320 {lab=vg1}
N 1690 -90 1940 -90 {lab=GND}
N 1940 -150 1940 -90 {lab=GND}
N 1640 -320 1640 -150 {lab=GND}
N 1640 -320 1690 -320 {lab=GND}
N 2510 -830 2580 -830 {lab=VDD}
N 2580 -900 2580 -830 {lab=VDD}
N 2510 -900 2580 -900 {lab=VDD}
N 2370 -750 2370 -700 {lab=v4_p1}
N 2370 -870 2370 -750 {lab=v4_p1}
N 2370 -960 2370 -930 {lab=VDD}
N 2510 -120 2510 -90 {lab=GND}
N 2510 -330 2560 -330 {lab=V_cm+}
N 2370 -700 2410 -700 {lab=v4_p1}
N 2510 -800 2510 -640 {lab=V_cm+}
N 2470 -700 2510 -700 {lab=V_cm+}
N 2370 -960 2510 -960 {lab=VDD}
N 2370 -830 2470 -830 {lab=v4_p1}
N 2370 -700 2370 -620 {lab=v4_p1}
N 2960 -120 2960 -10 {lab=GND}
N 2960 -230 3040 -230 {lab=v_mir_2}
N 3040 -230 3040 -150 {lab=v_mir_2}
N 3000 -150 3040 -150 {lab=v_mir_2}
N 2910 -150 2960 -150 {lab=GND}
N 3040 -150 3180 -150 {lab=v_mir_2}
N 2910 -150 2910 -90 {lab=GND}
N 2910 -90 2960 -90 {lab=GND}
N 3780 -150 3830 -150 {lab=GND}
N 3830 -150 3830 -90 {lab=GND}
N 3780 -90 3830 -90 {lab=GND}
N 3240 -150 3740 -150 {lab=v_mir_gate_2}
N 3780 -640 3780 -180 {lab=V_cm-}
N 3780 -960 3780 -860 {lab=VDD}
N 3420 -410 3420 -310 {lab=opamp_Vin+}
N 3420 -250 3420 -150 {lab=v_mir_gate_2}
N 2960 -480 2960 -350 {lab=vg2}
N 2960 -290 2960 -180 {lab=v_mir_2}
N 3000 -320 3210 -320 {lab=vg2}
N 3210 -320 3210 -190 {lab=vg2}
N 2960 -400 3040 -400 {lab=vg2}
N 3040 -400 3040 -320 {lab=vg2}
N 2960 -90 3210 -90 {lab=GND}
N 3210 -150 3210 -90 {lab=GND}
N 2910 -320 2910 -150 {lab=GND}
N 2910 -320 2960 -320 {lab=GND}
N 3780 -830 3850 -830 {lab=VDD}
N 3850 -900 3850 -830 {lab=VDD}
N 3780 -900 3850 -900 {lab=VDD}
N 3640 -750 3640 -700 {lab=v4_p2}
N 3640 -870 3640 -750 {lab=v4_p2}
N 3640 -960 3640 -930 {lab=VDD}
N 3780 -120 3780 -90 {lab=GND}
N 3780 -330 3830 -330 {lab=V_cm-}
N 3640 -700 3680 -700 {lab=v4_p2}
N 3780 -800 3780 -640 {lab=V_cm-}
N 3740 -700 3780 -700 {lab=V_cm-}
N 3640 -960 3780 -960 {lab=VDD}
N 3640 -830 3740 -830 {lab=v4_p2}
N 2960 -610 2960 -540 {lab=#net5}
N 2960 -510 3020 -510 {lab=VDD}
N 2860 -510 2920 -510 {lab=pfet_gate_10uA}
N 3020 -640 3020 -510 {lab=VDD}
N 3640 -700 3640 -620 {lab=v4_p2}
N 3640 -590 3700 -590 {lab=GND}
N 3540 -590 3600 -590 {lab=nfet_gate_10uA}
N 3640 -560 3640 -490 {lab=GND}
N 2960 -740 2960 -670 {lab=VDD}
N 2960 -640 3020 -640 {lab=VDD}
N 2860 -640 2920 -640 {lab=pfet_gate_10uA}
N 2860 -640 2860 -510 {lab=pfet_gate_10uA}
N 2960 -740 3020 -740 {lab=VDD}
N 3020 -740 3020 -640 {lab=VDD}
N 3700 -590 3700 -490 {lab=GND}
N 3640 -490 3700 -490 {lab=GND}
N 2370 -590 2430 -590 {lab=GND}
N 2270 -590 2330 -590 {lab=nfet_gate_10uA}
N 2370 -560 2370 -490 {lab=GND}
N 2430 -590 2430 -490 {lab=GND}
N 2370 -490 2430 -490 {lab=GND}
N 1690 -610 1690 -540 {lab=#net6}
N 1690 -510 1750 -510 {lab=VDD}
N 1590 -510 1650 -510 {lab=pfet_gate_10uA}
N 1750 -640 1750 -510 {lab=VDD}
N 1690 -740 1690 -670 {lab=VDD}
N 1690 -640 1750 -640 {lab=VDD}
N 1590 -640 1650 -640 {lab=pfet_gate_10uA}
N 1590 -640 1590 -510 {lab=pfet_gate_10uA}
N 1690 -740 1750 -740 {lab=VDD}
N 1750 -740 1750 -640 {lab=VDD}
N 9730 -4460 9860 -4460 {lab=V_OUT_Y}
N 9520 -4460 9670 -4460 {lab=V_OUT_Y}
N 9520 -4510 9520 -4460 {lab=V_OUT_Y}
N 9520 -4670 9520 -4570 {lab=Y}
N 9670 -4460 9730 -4460 {lab=V_OUT_Y}
N 8750 -4460 8880 -4460 {lab=V_OUT_X}
N 8940 -4460 9090 -4460 {lab=V_OUT_X}
N 9090 -4510 9090 -4460 {lab=V_OUT_X}
N 9090 -4670 9090 -4570 {lab=X}
N 8880 -4460 8940 -4460 {lab=V_OUT_X}
C {devices/vsource.sym} 1070 -3000 0 0 {name=VDD value="pwl(0 0 0.5us 0 1us 1.8)" savecurrent=false
* 1.8}
C {devices/gnd.sym} 1070 -2970 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} 1070 -3030 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/corner.sym} 860 -3050 0 0 {name=CORNER only_toplevel=false corner=tt}
C {sky130_fd_pr/nfet_01v8.sym} 6640 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7430 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6680 -2410 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7390 -2410 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6680 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7390 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 6840 -3400 0 0 {name=l11 lab=VDD}
C {lab_wire.sym} 6830 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb7}
C {lab_wire.sym} 6830 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb6}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1540 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 6960 -1420 0 1 {name=l12 lab=GND}
C {devices/gnd.sym} 6490 -1610 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 5080 -1540 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} 5060 -1420 0 0 {name=l14 lab=GND}
C {vdd.sym} 5060 -2460 0 0 {name=l15 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 4880 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5250 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6940 -1950 0 0 {name=M19
W=1
L=2.7
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6660 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3350 0 1 {name=M21
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3350 0 1 {name=M22
W=3.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5170 -3560 0 1 {name=M23
W=1.8
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5950 -3560 0 1 {name=M24
W=3.0
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 5350 -3770 0 0 {name=l16 lab=VDD}
C {lab_pin.sym} 6050 -3560 0 1 {name=p18 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 5270 -3350 0 1 {name=p19 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 6130 -3350 0 1 {name=p20 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 7410 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 10420 -2150 0 0 {name=M25
W=20
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10420 -2490 0 0 {name=M26
W=30
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 10440 -2230 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 10440 -1960 0 0 {name=l20 lab=GND}
C {vdd.sym} 10440 -2680 0 0 {name=l21 lab=VDD}
C {devices/gnd.sym} 10440 -2410 0 0 {name=l22 lab=GND}
C {lab_pin.sym} 10200 -2330 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 11260 -2330 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2540 1 0 {name=R10
L=14
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2560 2 1 {name=l23 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10620 -2100 1 1 {name=R11
L=14
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10620 -2080 0 0 {name=l24 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2540 3 1 {name=R12
L=14
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {devices/gnd.sym} 10850 -2560 2 0 {name=l25 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10850 -2100 3 0 {name=R13
L=14
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 10850 -2080 0 1 {name=l26 lab=GND}
C {lab_wire.sym} 10740 -2330 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 11050 -2150 0 1 {name=M27
W=20
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11050 -2490 0 1 {name=M28
W=30
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 11030 -2230 0 1 {name=l27 lab=VDD}
C {devices/gnd.sym} 11030 -1960 0 1 {name=l28 lab=GND}
C {vdd.sym} 11030 -2680 0 1 {name=l29 lab=VDD}
C {devices/gnd.sym} 11030 -2410 0 1 {name=l30 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 9430 -1630 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -1630 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 9290 -1890 0 0 {name=l31 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 9390 -1450 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9190 -1450 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 9290 -1320 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 9040 -1630 0 0 {name=p28 sig_type=std_logic lab=V_ref}
C {devices/vsource.sym} 11520 -2540 0 1 {name=Vref value=0.9 savecurrent=false
}
C {devices/gnd.sym} 11520 -2510 0 1 {name=l33 lab=GND}
C {lab_pin.sym} 11520 -2630 0 1 {name=p31 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 9530 -1630 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 9270 -1810 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8310 -1630 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8590 -1630 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 8450 -1890 0 1 {name=l34 lab=VDD}
C {lab_pin.sym} 8700 -1630 0 1 {name=p34 sig_type=std_logic lab=V_ref}
C {lab_wire.sym} 8200 -1630 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8470 -1810 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 8450 -1310 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 7540 -1610 0 0 {name=l36 lab=GND
value="sin(1.20 0.001 1Meg)"}
C {devices/vsource.sym} 6490 -1640 0 1 {name=V2 value="sin(0.2 -0.001 1Meg)" savecurrent=false
* 1.24
* }
C {devices/vsource.sym} 7540 -1640 0 0 {name=V1 value="sin(1.57 0.001 1Meg)" savecurrent=false
* * 1.24
* }
C {sky130_fd_pr/nfet_01v8.sym} 8770 -3940 0 1 {name=M37
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9840 -3940 0 0 {name=M38
W=34
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8770 -4670 0 1 {name=M39
W=80
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9840 -4670 0 0 {name=M40
W=80
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 9170 -4670 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 9440 -4670 0 0 {name=p46 sig_type=std_logic lab=Y}
C {lab_pin.sym} 8640 -4130 0 0 {name=p47 sig_type=std_logic lab=V_OUT_X}
C {lab_pin.sym} 9970 -4130 0 1 {name=p48 sig_type=std_logic lab=V_OUT_Y}
C {vdd.sym} 8750 -4770 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 8750 -3740 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 8910 -4060 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 8910 -4040 0 0 {name=l39 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 9700 -4060 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/gnd.sym} 9700 -4040 0 1 {name=l40 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 7280 -1540 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 7540 -1690 0 1 {name=p52 sig_type=std_logic lab=opamp_Vin+}
C {lab_pin.sym} 6490 -1690 0 0 {name=p53 sig_type=std_logic lab=opamp_Vin-}
C {simulator_commands_shown.sym} 80 -3300 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.x1.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm3.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm4.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm5.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm5.msky130_fd_pr__nfet_01v8[vth]
+@m.x1.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.x1.xm8.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.xm8.msky130_fd_pr__pfet_01v8[vth]
+@m.x1.x1.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x1.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x1.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x2.xm1.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm3.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.x1.x2.xm6.msky130_fd_pr__nfet_01v8[gm]
+@m.x1.x2.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm1.msky130_fd_pr__pfet_01v8[vth]
+@m.xm2.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__pfet_01v8[vth]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm3.msky130_fd_pr__pfet_01v8[vth]
+@m.xm4.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__pfet_01v8[vth]
+@m.xm5.msky130_fd_pr__pfet_01v8[gm]
+@m.xm5.msky130_fd_pr__pfet_01v8[vth]
+@m.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.xm6.msky130_fd_pr__pfet_01v8[vth]
+@m.xm7.msky130_fd_pr__nfet_01v8[gm]
+@m.xm7.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[vth]
+@m.xm9.msky130_fd_pr__nfet_01v8[gm]
+@m.xm9.msky130_fd_pr__nfet_01v8[vth]
+@m.xm10.msky130_fd_pr__pfet_01v8[gm]
+@m.xm10.msky130_fd_pr__pfet_01v8[vth]
+@m.xm11.msky130_fd_pr__pfet_01v8[gm]
+@m.xm11.msky130_fd_pr__pfet_01v8[vth]
+@m.xm12.msky130_fd_pr__pfet_01v8[gm]
+@m.xm12.msky130_fd_pr__pfet_01v8[vth]
+@m.xm13.msky130_fd_pr__pfet_01v8[gm]
+@m.xm13.msky130_fd_pr__pfet_01v8[vth]
+@m.xm14.msky130_fd_pr__nfet_01v8[gm]
+@m.xm14.msky130_fd_pr__nfet_01v8[vth]
+@m.xm15.msky130_fd_pr__nfet_01v8[gm]
+@m.xm15.msky130_fd_pr__nfet_01v8[vth]
+@m.xm16.msky130_fd_pr__nfet_01v8[gm]
+@m.xm16.msky130_fd_pr__nfet_01v8[vth]
+@m.xm17.msky130_fd_pr__nfet_01v8[gm]
+@m.xm17.msky130_fd_pr__nfet_01v8[vth]
+@m.xm18.msky130_fd_pr__nfet_01v8[gm]
+@m.xm18.msky130_fd_pr__nfet_01v8[vth]
+@m.xm19.msky130_fd_pr__nfet_01v8[gm]
+@m.xm19.msky130_fd_pr__nfet_01v8[vth]
+@m.xm20.msky130_fd_pr__nfet_01v8[gm]
+@m.xm20.msky130_fd_pr__nfet_01v8[vth]
+@m.xm21.msky130_fd_pr__pfet_01v8[gm]
+@m.xm21.msky130_fd_pr__pfet_01v8[vth]
+@m.xm22.msky130_fd_pr__pfet_01v8[gm]
+@m.xm22.msky130_fd_pr__pfet_01v8[vth]
+@m.xm23.msky130_fd_pr__pfet_01v8[gm]
+@m.xm23.msky130_fd_pr__pfet_01v8[vth]
+@m.xm24.msky130_fd_pr__pfet_01v8[gm]
+@m.xm24.msky130_fd_pr__pfet_01v8[vth]
+@m.xm25.msky130_fd_pr__nfet_01v8[gm]
+@m.xm25.msky130_fd_pr__nfet_01v8[vth]
+@m.xm26.msky130_fd_pr__pfet_01v8[gm]
+@m.xm26.msky130_fd_pr__pfet_01v8[vth]
+@m.xm27.msky130_fd_pr__nfet_01v8[gm]
+@m.xm27.msky130_fd_pr__nfet_01v8[vth]
+@m.xm28.msky130_fd_pr__pfet_01v8[gm]
+@m.xm28.msky130_fd_pr__pfet_01v8[vth]
+@m.xm29.msky130_fd_pr__pfet_01v8[gm]
+@m.xm29.msky130_fd_pr__pfet_01v8[vth]
+@m.xm30.msky130_fd_pr__pfet_01v8[gm]
+@m.xm30.msky130_fd_pr__pfet_01v8[vth]
+@m.xm31.msky130_fd_pr__nfet_01v8[gm]
+@m.xm31.msky130_fd_pr__nfet_01v8[vth]
+@m.xm32.msky130_fd_pr__nfet_01v8[gm]
+@m.xm32.msky130_fd_pr__nfet_01v8[vth]
+@m.xm33.msky130_fd_pr__pfet_01v8[gm]
+@m.xm33.msky130_fd_pr__pfet_01v8[vth]
+@m.xm34.msky130_fd_pr__pfet_01v8[gm]
+@m.xm34.msky130_fd_pr__pfet_01v8[vth]
+@m.xm35.msky130_fd_pr__pfet_01v8[gm]
+@m.xm35.msky130_fd_pr__pfet_01v8[vth]
+@m.xm36.msky130_fd_pr__pfet_01v8[gm]
+@m.xm36.msky130_fd_pr__pfet_01v8[vth]
+@m.xm37.msky130_fd_pr__nfet_01v8[gm]
+@m.xm37.msky130_fd_pr__nfet_01v8[vth]
+@m.xm38.msky130_fd_pr__nfet_01v8[gm]
+@m.xm38.msky130_fd_pr__nfet_01v8[vth]
+@m.xm39.msky130_fd_pr__pfet_01v8[gm]
+@m.xm39.msky130_fd_pr__pfet_01v8[vth]
+@m.xm40.msky130_fd_pr__pfet_01v8[gm]
+@m.xm40.msky130_fd_pr__pfet_01v8[vth]
+@m.xm41.msky130_fd_pr__nfet_01v8[gm]
+@m.xm41.msky130_fd_pr__nfet_01v8[vth]
+@m.xm42.msky130_fd_pr__pfet_01v8[gm]
+@m.xm42.msky130_fd_pr__pfet_01v8[vth]
+@m.xm43.msky130_fd_pr__pfet_01v8[gm]
+@m.xm43.msky130_fd_pr__pfet_01v8[vth]
+@m.xm44.msky130_fd_pr__nfet_01v8[gm]
+@m.xm44.msky130_fd_pr__nfet_01v8[vth]
+@m.xm45.msky130_fd_pr__nfet_01v8[gm]
+@m.xm45.msky130_fd_pr__nfet_01v8[vth]
+@m.xm46.msky130_fd_pr__nfet_01v8[gm]
+@m.xm46.msky130_fd_pr__nfet_01v8[vth]
+@m.xm47.msky130_fd_pr__nfet_01v8[gm]
+@m.xm47.msky130_fd_pr__nfet_01v8[vth]
+@m.xm48.msky130_fd_pr__nfet_01v8[gm]
+@m.xm48.msky130_fd_pr__nfet_01v8[vth]
+@m.xm49.msky130_fd_pr__nfet_01v8[gm]
+@m.xm49.msky130_fd_pr__nfet_01v8[vth]

* .ic v(v_top) = 1.8

.control

  save all
  * dc V1 1.238 1.242 0.0001
  * dc VDD 0 1.8 0.9
  * dc temp -40 120 10 VDD 0 4.0 0.2
  * dc VDD 0 2.0 0.02 temp -40 120 40
  * dc VDD 0 2.0 0.01
  tran 0.5n 4.0u
  * tran 0.1ns 30us
  * ac dec 20 1 1T
  remzerovec
  write tb_opamp_full_compensation.raw
  set appendwrite
  let first_out = x - y
  let second_out = v_out_x - v_out_y

.endc


"}
C {lab_wire.sym} 6960 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 6660 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 7410 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 6830 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6390 -1540 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 5060 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 6660 -3000 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 7410 -3000 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 5150 -3470 0 1 {name=p29 sig_type=std_logic lab=V1}
C {lab_pin.sym} 5930 -3470 0 1 {name=p30 sig_type=std_logic lab=V2}
C {lab_pin.sym} 9410 -1550 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 9250 -1730 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 8490 -1730 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 8940 -1810 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 9020 -1460 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 11150 -2100 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 11120 -2540 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 9310 -3940 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 6830 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3350 0 1 {name=M1
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3350 0 1 {name=M2
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3440 -3560 0 1 {name=M3
W=0.81
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4220 -3560 0 1 {name=M4
W=3.1
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3620 -3770 0 0 {name=l1 lab=VDD}
C {lab_pin.sym} 4320 -3560 0 1 {name=p1 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 3540 -3350 0 1 {name=p2 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 4400 -3350 0 1 {name=p3 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 3420 -3470 0 1 {name=p4 sig_type=std_logic lab=V3}
C {lab_pin.sym} 4200 -3470 0 1 {name=p5 sig_type=std_logic lab=V4}
C {devices/ngspice_get_value.sym} 3310 -3560 0 1 {name=r5 node=v(@m.xm3.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 3310 -3390 0 1 {name=r6 node=v(@m.xm1.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3550 0 1 {name=r3 node=v(@m.xm4.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 4090 -3380 0 1 {name=r4 node=v(@m.xm2.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -3450 0 1 {name=M5
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3350 0 1 {name=M6
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2550 -3560 0 1 {name=M43
W=3.2
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 1950 -3770 0 0 {name=l6 lab=VDD}
C {lab_pin.sym} 2650 -3560 0 1 {name=p6 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 1870 -3450 0 1 {name=p7 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2730 -3350 0 1 {name=p8 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2530 -3470 0 1 {name=p12 sig_type=std_logic lab=V5}
C {devices/ngspice_get_value.sym} 1640 -3490 0 1 {name=r2 node=v(@m.xm5.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3550 0 1 {name=r7 node=v(@m.xm43.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 2420 -3380 0 1 {name=r8 node=v(@m.xm6.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 6820 -3760 0 1 {name=p11 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 6900 -3550 0 1 {name=p49 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 7040 -3760 0 1 {name=p50 sig_type=std_logic lab=Vb5}
C {lab_pin.sym} 7120 -3550 0 1 {name=p51 sig_type=std_logic lab=Vb4}
C {devices/ngspice_get_value.sym} 5050 -3560 0 1 {name=r1 node=v(@m.xm23.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5050 -3390 0 1 {name=r9 node=v(@m.xm21.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3550 0 1 {name=r14 node=v(@m.xm24.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 5830 -3380 0 1 {name=r15 node=v(@m.xm22.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_pin.sym} 7250 -3760 0 1 {name=p54 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 7330 -3550 0 1 {name=p55 sig_type=std_logic lab=Vb2}
C {devices/ngspice_get_value.sym} 6900 -1890 2 0 {name=r17 node=v(@m.xm19.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6709.776713144086 -3150 2 1 {name=r16 node=v(@m.xm13.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {lab_wire.sym} 10320 -2100 0 0 {name=p14 sig_type=std_logic lab=V_4}
C {lab_wire.sym} 10350 -2540 0 0 {name=p56 sig_type=std_logic lab=V_3}
C {devices/ngspice_get_value.sym} 6709.776713144086 -2730 2 1 {name=r18 node=v(@m.xm11.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 6709.776713144086 -2430 0 0 {name=r19 node=v(@m.xm9.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/vdd.sym} 960 -2550 0 0 {name=l9 lab=VDD}
C {devices/gnd.sym} 960 -2410 0 0 {name=l10 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2300 -1980 0 1 {name=M20
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2260 -2250 0 0 {name=M42
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 2280 -2330 0 0 {name=l41 lab=VDD}
C {devices/gnd.sym} 2280 -1890 0 0 {name=l42 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 1730 -3080 0 0 {name=M44
W=2
L=0.5
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1750 -2990 0 1 {name=l43 lab=GND}
C {lab_wire.sym} 2450 -1980 0 1 {name=p60 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 1640 -3080 0 0 {name=p61 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 2510 -3070 0 0 {name=M45
W=2
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2530 -2980 0 1 {name=l7 lab=GND}
C {lab_wire.sym} 2420 -3070 0 0 {name=p62 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 6940 -3010 0 0 {name=M50
W=2
L=0.5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6860 -3010 0 0 {name=p67 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 5040 -2370 0 0 {name=M51
W=2
L=0.5
nf=1
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8430 -1390 0 0 {name=M53
W=2
L=0.5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8340 -1390 0 0 {name=p70 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 10340 -2590 0 0 {name=p72 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 11130 -2590 0 1 {name=p73 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 5260 -2070 0 1 {name=p75 sig_type=std_logic lab=VGS9}
C {sky130_fd_pr/nfet_01v8.sym} 10420 -2050 0 0 {name=M54
W=2
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11050 -2050 0 1 {name=M55
W=2
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10420 -2590 0 0 {name=M56
W=2
L=0.5
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11050 -2590 0 1 {name=M57
W=2
L=0.5
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1220 -2480 0 0 {name=M58
W=10
L=0.3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1240 -1730 0 1 {name=R20
L=32
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/vdd.sym} 1620 -2210 2 0 {name=l18 lab=VDD}
C {devices/gnd.sym} 1620 -2330 2 0 {name=l44 lab=GND
W=4}
C {devices/gnd.sym} 1920 -1880 1 0 {name=l45 lab=GND
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 1940 -1880 0 0 {name=R21
L=12
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 1920 -2270 0 0 {name=M59
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 1940 -1990 0 1 {name=p76 sig_type=std_logic lab=V_CUR_REF_REG}
C {lab_wire.sym} 1340 -2290 0 1 {name=p77 sig_type=std_logic lab=V_REF}
C {lab_wire.sym} 2020 -2170 0 1 {name=p78 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 3400 -3080 0 0 {name=M46
W=2
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3420 -2990 0 1 {name=l2 lab=GND}
C {lab_wire.sym} 3310 -3080 0 0 {name=p63 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 4180 -3070 0 0 {name=M47
W=2
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 4200 -2980 0 1 {name=l5 lab=GND}
C {lab_wire.sym} 4090 -3070 0 0 {name=p64 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 5130 -3080 0 0 {name=M48
W=2
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5150 -2990 0 1 {name=l8 lab=GND}
C {lab_wire.sym} 5040 -3080 0 0 {name=p65 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 5910 -3070 0 0 {name=M49
W=2
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 5930 -2980 0 1 {name=l17 lab=GND}
C {lab_wire.sym} 5820 -3070 0 0 {name=p66 sig_type=std_logic lab=nfet_gate_10uA}
C {devices/gnd.sym} 1580 -1590 0 0 {name=l46 lab=GND}
C {devices/gnd.sym} 1260 -1730 3 0 {name=l47 lab=GND}
C {devices/vdd.sym} 1590 -2590 0 0 {name=l48 lab=VDD}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/BGR_vtop_out.sym} 960 -2480 0 0 {name=x1}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 1620 -2270 2 1 {name=x2}
C {lab_wire.sym} 1100 -2480 0 1 {name=p81 sig_type=std_logic lab=V_TOP}
C {lab_wire.sym} 10330 -2050 0 0 {name=p85 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 11140 -2050 0 1 {name=p71 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 2150 -2250 0 0 {name=p59 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 4930 -2370 0 0 {name=p74 sig_type=std_logic lab=pfet_gate_10uA}
C {devices/gnd.sym} 9860 -3740 0 0 {name=l57 lab=GND}
C {vdd.sym} 9860 -4770 0 0 {name=l59 lab=VDD}
C {sky130_fd_pr/nfet_01v8.sym} 9290 -3820 0 0 {name=M52
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9290 -3670 0 0 {name=M64
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9290 -3520 0 0 {name=M65
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9290 -3370 0 0 {name=M66
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9290 -3220 0 0 {name=M67
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 9220 -3820 0 0 {name=p68 sig_type=std_logic lab=nfet_gate_10uA}
C {devices/gnd.sym} 9310 -3100 0 0 {name=l58 lab=GND}
C {gnd.sym} 1690 -20 0 1 {name=l50 lab=GND}
C {gnd.sym} 2510 -90 0 0 {name=l51 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2150 -280 2 0 {name=C3 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {lab_wire.sym} 1770 -230 0 1 {name=p58 sig_type=std_logic lab=v_mir_1}
C {lab_wire.sym} 2150 -150 2 0 {name=p69 sig_type=std_logic lab=v_mir_gate_1}
C {lab_wire.sym} 1940 -320 0 1 {name=p79 sig_type=std_logic lab=vg1}
C {sky130_fd_pr/nfet_01v8.sym} 1710 -320 0 1 {name=M60
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1710 -150 0 1 {name=M61
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1940 -170 3 1 {name=M62
W=1
L=5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2490 -150 0 0 {name=M63
W=3
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2490 -830 0 0 {name=M68
W=3
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 2510 -960 0 1 {name=l52 lab=VDD}
C {devices/gnd.sym} 2440 -680 0 0 {name=l53 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2440 -700 3 0 {name=R25
L=7.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_pin.sym} 2150 -410 0 0 {name=p80 sig_type=std_logic lab=opamp_Vin-}
C {lab_wire.sym} 2370 -700 2 1 {name=p82 sig_type=std_logic lab=v4_p1}
C {lab_wire.sym} 2560 -330 0 1 {name=p89 sig_type=std_logic lab=V_cm+}
C {lab_wire.sym} 7540 -1800 0 1 {name=p95 sig_type=std_logic lab=V_cm+}
C {lab_wire.sym} 6490 -1800 0 0 {name=p96 sig_type=std_logic lab=V_cm-}
C {gnd.sym} 2960 -20 0 1 {name=l54 lab=GND}
C {gnd.sym} 3780 -90 0 0 {name=l55 lab=GND}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3420 -280 2 0 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {lab_wire.sym} 3040 -230 0 1 {name=p83 sig_type=std_logic lab=v_mir_2}
C {lab_wire.sym} 3420 -150 2 0 {name=p84 sig_type=std_logic lab=v_mir_gate_2}
C {lab_wire.sym} 3210 -320 0 1 {name=p86 sig_type=std_logic lab=vg2}
C {sky130_fd_pr/nfet_01v8.sym} 2980 -320 0 1 {name=M69
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2980 -150 0 1 {name=M70
W=1
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3210 -170 3 1 {name=M71
W=1
L=5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -150 0 0 {name=M72
W=3
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -830 0 0 {name=M73
W=3
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {vdd.sym} 3780 -960 0 1 {name=l56 lab=VDD}
C {devices/gnd.sym} 3710 -680 0 0 {name=l60 lab=GND}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 3710 -700 3 0 {name=R24
L=7.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_pin.sym} 3420 -410 0 0 {name=p87 sig_type=std_logic lab=opamp_Vin+}
C {lab_wire.sym} 3640 -700 2 1 {name=p88 sig_type=std_logic lab=v4_p2}
C {lab_wire.sym} 3830 -330 0 1 {name=p90 sig_type=std_logic lab=V_cm-}
C {vdd.sym} 2960 -740 0 0 {name=l61 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2940 -510 0 0 {name=M74
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2860 -510 0 0 {name=p91 sig_type=std_logic lab=pfet_gate_10uA}
C {gnd.sym} 3640 -490 0 0 {name=l62 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 3620 -590 0 0 {name=M75
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 3540 -590 0 0 {name=p92 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 2940 -640 0 0 {name=M76
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {gnd.sym} 2370 -490 0 0 {name=l63 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} 2350 -590 0 0 {name=M79
W=2
L=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2270 -590 0 0 {name=p94 sig_type=std_logic lab=nfet_gate_10uA}
C {vdd.sym} 1690 -740 0 0 {name=l49 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1670 -510 0 0 {name=M78
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 1590 -510 0 0 {name=p93 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 1670 -640 0 0 {name=M81
W=2
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 8789.776713144085 -4640 2 1 {name=r26 node=v(@m.xm39.msky130_fd_pr__pfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 8789.776713144085 -3990 0 0 {name=r27 node=v(@m.xm37.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9520 -4540 0 0 {name=C2 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 9090 -4540 0 1 {name=C4 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
