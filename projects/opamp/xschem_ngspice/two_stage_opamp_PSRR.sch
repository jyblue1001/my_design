v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {N 50uA} 2130 -3100 0 0 1 1 {}
T {N 50uA} 2900 -3100 0 0 1 1 {}
T {P 100uA} 5030 -2420 0 0 1 1 {}
T {P 20uA} 6710 -3050 0 0 1 1 {}
T {N 20uA} 8910 -1750 0 0 1 1 {}
T {N 30uA} 10420 -2120 0 0 1 1 {}
T {P 30uA} 10440 -2810 0 0 1 1 {}
T {P 30uA} 11570 -2810 0 1 1 1 {}
T {N 30uA} 11590 -2120 0 1 1 1 {}
T {p,nmos gate reference current branch} 1410 -2430 0 0 2 2 {}
T {1st stage pmos current source load voltage bias references} 1090 -4110 0 0 2 2 {}
T {1st stage} 7400 -4540 0 0 4 4 {}
T {1st gain stage} 6350 -3840 0 0 2 2 {}
T {1st stage CMFB} 9620 -3120 0 0 2 2 {}
T {2nd stage} 13530 -4340 0 0 4 4 {}
N 6310 -1770 6310 -1680 {lab=V_p}
N 6310 -1680 7060 -1680 {lab=V_p}
N 7060 -1770 7060 -1680 {lab=V_p}
N 6310 -2380 6310 -1830 {lab=VD1}
N 7060 -2380 7060 -1830 {lab=VD2}
N 6350 -2410 7020 -2410 {lab=Vb1}
N 6310 -2740 6310 -2440 {lab=X}
N 7060 -2740 7060 -2440 {lab=Y}
N 6310 -3160 6310 -2800 {lab=VD7}
N 7060 -3160 7060 -2800 {lab=VD6}
N 6350 -2770 7020 -2770 {lab=Vb6}
N 7060 -2770 7130 -2770 {lab=VD6}
N 7130 -2840 7130 -2770 {lab=VD6}
N 7060 -2840 7130 -2840 {lab=VD6}
N 6240 -2770 6310 -2770 {lab=VD7}
N 6240 -2840 6240 -2770 {lab=VD7}
N 6240 -2840 6310 -2840 {lab=VD7}
N 6310 -3340 6310 -3220 {lab=VDD_PSRR}
N 7060 -3340 7060 -3220 {lab=VDD_PSRR}
N 6350 -3190 7020 -3190 {lab=Vb7}
N 7060 -3190 7130 -3190 {lab=VDD_PSRR}
N 7130 -3260 7130 -3190 {lab=VDD_PSRR}
N 7060 -3260 7130 -3260 {lab=VDD_PSRR}
N 6240 -3190 6310 -3190 {lab=VDD_PSRR}
N 6240 -3260 6240 -3190 {lab=VDD_PSRR}
N 6240 -3260 6310 -3260 {lab=VDD_PSRR}
N 6310 -3340 7060 -3340 {lab=VDD_PSRR}
N 6260 -2410 6310 -2410 {lab=GNDA}
N 6260 -2410 6260 -2350 {lab=GNDA}
N 6260 -2350 7120 -2350 {lab=GNDA}
N 7120 -2410 7120 -2350 {lab=GNDA}
N 7060 -2410 7120 -2410 {lab=GNDA}
N 6490 -3400 6490 -3340 {lab=VDD_PSRR}
N 6760 -1800 7060 -1800 {lab=GNDA}
N 6310 -1800 6760 -1800 {lab=GNDA}
N 6610 -1680 6610 -1570 {lab=V_p}
N 6760 -1800 6760 -1540 {lab=GNDA}
N 6610 -1540 6760 -1540 {lab=GNDA}
N 6610 -1510 6610 -1360 {lab=GNDA}
N 6610 -1460 6760 -1460 {lab=GNDA}
N 6760 -1540 6760 -1460 {lab=GNDA}
N 7100 -1800 7190 -1800 {lab=VIN+}
N 4960 -1680 4960 -1570 {lab=V_p_mir}
N 4880 -1540 4960 -1540 {lab=GNDA}
N 4960 -1510 4960 -1390 {lab=GNDA}
N 4880 -1460 4960 -1460 {lab=GNDA}
N 4880 -1540 4880 -1460 {lab=GNDA}
N 5000 -1540 6570 -1540 {lab=VGS9}
N 4960 -2500 4960 -2400 {lab=VDDA}
N 5040 -1800 5130 -1800 {lab=GNDA}
N 4800 -1800 5040 -1800 {lab=GNDA}
N 4800 -1770 4800 -1680 {lab=V_p_mir}
N 4800 -1680 5130 -1680 {lab=V_p_mir}
N 5130 -1770 5130 -1680 {lab=V_p_mir}
N 4880 -1800 4880 -1540 {lab=GNDA}
N 4800 -1950 4800 -1830 {lab=VGS9}
N 4800 -1950 5130 -1950 {lab=VGS9}
N 5130 -1950 5130 -1830 {lab=VGS9}
N 4960 -2150 4960 -1950 {lab=VGS9}
N 5170 -1800 5240 -1800 {lab=VIN-}
N 4690 -1800 4760 -1800 {lab=VIN+}
N 4960 -2070 5530 -2070 {lab=VGS9}
N 5530 -2070 5530 -1540 {lab=VGS9}
N 6610 -2060 6610 -1980 {lab=Vb1}
N 6610 -1950 6760 -1950 {lab=GNDA}
N 6610 -1920 6610 -1680 {lab=V_p}
N 6610 -2410 6610 -2120 {lab=Vb1}
N 6480 -1950 6570 -1950 {lab=Vb1}
N 6480 -2210 6480 -1950 {lab=Vb1}
N 6480 -2210 6610 -2210 {lab=Vb1}
N 6610 -2980 6610 -2410 {lab=Vb1}
N 6610 -3340 6610 -3040 {lab=VDD_PSRR}
N 10710 -2340 10710 -2290 {lab=VDD_PSRR}
N 10710 -2130 10710 -2070 {lab=GNDA}
N 10710 -2230 10710 -2190 {lab=V_4}
N 10710 -2570 10710 -2520 {lab=GNDA}
N 10710 -2680 10710 -2630 {lab=V_3}
N 10590 -2600 10590 -2260 {lab=X}
N 11340 -2600 11410 -2600 {lab=Y}
N 11410 -2600 11410 -2260 {lab=Y}
N 11340 -2260 11410 -2260 {lab=Y}
N 10470 -2440 10590 -2440 {lab=X}
N 11410 -2440 11530 -2440 {lab=Y}
N 11150 -2650 11300 -2650 {lab=V_1}
N 11150 -2210 11300 -2210 {lab=V_2}
N 10710 -2600 10790 -2600 {lab=VDD_PSRR}
N 10710 -2760 10790 -2760 {lab=VDD_PSRR}
N 10710 -2810 10710 -2730 {lab=VDD_PSRR}
N 10790 -2760 10790 -2600 {lab=VDD_PSRR}
N 10710 -2100 10790 -2100 {lab=GNDA}
N 10710 -2260 10790 -2260 {lab=GNDA}
N 10790 -2260 10790 -2100 {lab=GNDA}
N 11300 -2340 11300 -2290 {lab=VDD_PSRR}
N 11300 -2130 11300 -2070 {lab=GNDA}
N 11300 -2230 11300 -2190 {lab=V_2}
N 11300 -2570 11300 -2520 {lab=GNDA}
N 11300 -2680 11300 -2630 {lab=V_1}
N 11220 -2600 11300 -2600 {lab=VDD_PSRR}
N 11220 -2760 11300 -2760 {lab=VDD_PSRR}
N 11300 -2810 11300 -2730 {lab=VDD_PSRR}
N 11220 -2760 11220 -2600 {lab=VDD_PSRR}
N 11220 -2100 11300 -2100 {lab=GNDA}
N 11220 -2260 11300 -2260 {lab=GNDA}
N 11220 -2260 11220 -2100 {lab=GNDA}
N 11010 -2650 11010 -2210 {lab=V_tot}
N 9930 -1900 9930 -1830 {lab=V_err_p}
N 9690 -1900 9930 -1900 {lab=V_err_p}
N 9690 -1900 9690 -1830 {lab=V_err_p}
N 9810 -2160 9810 -1900 {lab=V_err_p}
N 9810 -2340 9810 -2220 {lab=VDD_PSRR}
N 9930 -1770 9930 -1470 {lab=err_opamp_mir}
N 9690 -1770 9690 -1470 {lab=err_opamp_out}
N 9930 -1410 9930 -1360 {lab=GNDA}
N 9690 -1360 9930 -1360 {lab=GNDA}
N 9690 -1410 9690 -1360 {lab=GNDA}
N 9810 -1360 9810 -1310 {lab=GNDA}
N 9690 -1800 9930 -1800 {lab=VDD_PSRR}
N 9730 -1440 9890 -1440 {lab=err_opamp_mir}
N 9650 -1440 9690 -1440 {lab=GNDA}
N 9650 -1440 9650 -1390 {lab=GNDA}
N 9650 -1390 9690 -1390 {lab=GNDA}
N 9930 -1440 9970 -1440 {lab=GNDA}
N 9970 -1440 9970 -1390 {lab=GNDA}
N 9930 -1390 9970 -1390 {lab=GNDA}
N 9830 -1520 9930 -1520 {lab=err_opamp_mir}
N 9830 -1520 9830 -1440 {lab=err_opamp_mir}
N 11010 -2210 11010 -1800 {lab=V_tot}
N 9560 -1800 9650 -1800 {lab=V_err_amp_ref}
N 6760 -1540 6910 -1540 {lab=GNDA}
N 6760 -1460 6910 -1460 {lab=GNDA}
N 6910 -1510 6910 -1460 {lab=GNDA}
N 6910 -1680 6910 -1570 {lab=V_p}
N 9970 -1800 11010 -1800 {lab=V_tot}
N 9810 -2190 9850 -2190 {lab=VDD_PSRR}
N 9850 -2250 9850 -2190 {lab=VDD_PSRR}
N 9810 -2250 9850 -2250 {lab=VDD_PSRR}
N 9850 -2190 9850 -1800 {lab=VDD_PSRR}
N 8690 -2070 8690 -2000 {lab=V_err_mir_p}
N 8690 -2070 8930 -2070 {lab=V_err_mir_p}
N 8930 -2070 8930 -2000 {lab=V_err_mir_p}
N 8810 -2160 8810 -2070 {lab=V_err_mir_p}
N 8810 -2340 8810 -2220 {lab=VDD_PSRR}
N 8690 -1970 8930 -1970 {lab=VDD_PSRR}
N 8970 -1970 9060 -1970 {lab=V_err_amp_ref}
N 8770 -2190 8810 -2190 {lab=VDD_PSRR}
N 8770 -2250 8770 -2190 {lab=VDD_PSRR}
N 8770 -2250 8810 -2250 {lab=VDD_PSRR}
N 8770 -2190 8770 -1970 {lab=VDD_PSRR}
N 8850 -2190 9770 -2190 {lab=V_gate}
N 8690 -1940 8690 -1880 {lab=V_gate}
N 8690 -1880 8930 -1880 {lab=V_gate}
N 8930 -1940 8930 -1880 {lab=V_gate}
N 8810 -1880 8810 -1760 {lab=V_gate}
N 8560 -1970 8650 -1970 {lab=V_tot}
N 8810 -1700 8810 -1630 {lab=GNDA}
N 9300 -2190 9300 -1820 {lab=V_gate}
N 8810 -1820 9300 -1820 {lab=V_gate}
N 6950 -1540 8520 -1540 {lab=err_opamp_out}
N 8520 -1540 9540 -1540 {lab=err_opamp_out}
N 9540 -1540 9690 -1540 {lab=err_opamp_out}
N 6760 -2090 6760 -1800 {lab=GNDA}
N 6760 -2350 6760 -2090 {lab=GNDA}
N 13550 -2860 13550 -2220 {lab=VOUT-}
N 14620 -2860 14620 -2220 {lab=VOUT+}
N 14620 -2890 14690 -2890 {lab=VDD_PSRR}
N 14690 -2960 14690 -2890 {lab=VDD_PSRR}
N 14620 -2960 14690 -2960 {lab=VDD_PSRR}
N 13480 -2890 13550 -2890 {lab=VDD_PSRR}
N 13480 -2960 13550 -2960 {lab=VDD_PSRR}
N 13480 -2960 13480 -2890 {lab=VDD_PSRR}
N 13550 -3040 13550 -2920 {lab=VDD_PSRR}
N 14620 -3040 14620 -2920 {lab=VDD_PSRR}
N 13550 -2160 13550 -1990 {lab=GNDA}
N 14620 -2160 14620 -1990 {lab=GNDA}
N 14620 -2120 14690 -2120 {lab=GNDA}
N 14690 -2190 14690 -2120 {lab=GNDA}
N 14620 -2190 14690 -2190 {lab=GNDA}
N 13480 -2120 13550 -2120 {lab=GNDA}
N 13480 -2190 13550 -2190 {lab=GNDA}
N 13480 -2190 13480 -2120 {lab=GNDA}
N 13590 -2890 13920 -2890 {lab=X}
N 14250 -2890 14580 -2890 {lab=Y}
N 13310 -2380 13550 -2380 {lab=VOUT-}
N 14620 -2380 14870 -2380 {lab=VOUT+}
N 14490 -2310 14620 -2310 {lab=VOUT+}
N 14090 -2190 14580 -2190 {lab=V_b}
N 14150 -2310 14430 -2310 {lab=V_b}
N 14150 -2310 14150 -2190 {lab=V_b}
N 13550 -2310 13680 -2310 {lab=VOUT-}
N 13740 -2310 14030 -2310 {lab=V_b}
N 13590 -2190 14090 -2190 {lab=V_b}
N 14030 -2310 14030 -2190 {lab=V_b}
N 10920 -2210 11090 -2210 {lab=V_tot}
N 10920 -2650 11090 -2650 {lab=V_tot}
N 10710 -2650 10860 -2650 {lab=V_3}
N 10710 -2210 10860 -2210 {lab=V_4}
N 10590 -2600 10670 -2600 {lab=X}
N 10590 -2260 10670 -2260 {lab=X}
N 6140 -1800 6270 -1800 {lab=VIN-}
N 11300 -2210 11420 -2210 {lab=V_2}
N 11300 -2650 11390 -2650 {lab=V_1}
N 6310 -1680 7060 -1680 {lab=V_p}
N 5790 -1800 6140 -1800 {lab=VIN-}
N 5240 -1800 5790 -1800 {lab=VIN-}
N 4690 -1900 5790 -1900 {lab=VIN+}
N 4690 -1900 4690 -1800 {lab=VIN+}
N 7190 -1900 7190 -1800 {lab=VIN+}
N 5790 -1900 7190 -1900 {lab=VIN+}
N 6140 -1740 6140 -1670 {lab=VIN-}
N 7190 -1740 7190 -1670 {lab=VIN+}
N 4960 -2340 4960 -2150 {lab=VGS9}
N 2010 -3420 2010 -3210 {lab=Vb6}
N 2790 -3320 2790 -3200 {lab=Vb7}
N 2790 -3530 2790 -3380 {lab=V5}
N 2720 -3350 2790 -3350 {lab=V5}
N 2720 -3420 2720 -3350 {lab=V5}
N 2720 -3420 2790 -3420 {lab=V5}
N 1940 -3450 2010 -3450 {lab=VDDA}
N 1940 -3520 1940 -3450 {lab=VDDA}
N 1940 -3520 2010 -3520 {lab=VDDA}
N 2790 -3710 2790 -3590 {lab=VDDA}
N 2720 -3560 2790 -3560 {lab=VDDA}
N 2720 -3630 2720 -3560 {lab=VDDA}
N 2720 -3630 2790 -3630 {lab=VDDA}
N 2370 -3800 2370 -3710 {lab=VDDA}
N 2010 -3710 2790 -3710 {lab=VDDA}
N 2050 -3450 2130 -3450 {lab=Vb6}
N 2830 -3560 2910 -3560 {lab=Vb7}
N 2910 -3560 2910 -3250 {lab=Vb7}
N 2790 -3250 2910 -3250 {lab=Vb7}
N 2010 -3350 2130 -3350 {lab=Vb6}
N 2830 -3350 2990 -3350 {lab=Vb6}
N 2130 -3450 2130 -3350 {lab=Vb6}
N 2010 -3710 2010 -3480 {lab=VDDA}
N 6610 -2120 6610 -2060 {lab=Vb1}
N 10590 -2210 10710 -2210 {lab=V_4}
N 10620 -2650 10710 -2650 {lab=V_3}
N 2380 -2150 2380 -2040 {lab=VDDA}
N 2380 -2010 2430 -2010 {lab=VDDA}
N 2430 -2070 2430 -2010 {lab=VDDA}
N 2380 -2070 2430 -2070 {lab=VDDA}
N 2250 -2010 2340 -2010 {lab=pfet_gate_10uA}
N 2380 -1520 2380 -1430 {lab=GNDA}
N 2330 -1490 2380 -1490 {lab=GNDA}
N 2330 -1550 2330 -1490 {lab=GNDA}
N 2330 -1550 2380 -1550 {lab=GNDA}
N 2380 -1980 2380 -1580 {lab=nfet_gate_10uA}
N 2010 -3050 2010 -2960 {lab=GNDA}
N 2010 -3020 2060 -3020 {lab=GNDA}
N 2060 -3080 2060 -3020 {lab=GNDA}
N 2010 -3080 2060 -3080 {lab=GNDA}
N 2010 -3210 2010 -3110 {lab=Vb6}
N 2450 -1620 2450 -1550 {lab=nfet_gate_10uA}
N 2380 -1620 2450 -1620 {lab=nfet_gate_10uA}
N 2420 -1550 2550 -1550 {lab=nfet_gate_10uA}
N 1900 -3080 1970 -3080 {lab=nfet_gate_10uA}
N 2790 -3040 2790 -2960 {lab=GNDA}
N 2790 -3010 2840 -3010 {lab=GNDA}
N 2840 -3070 2840 -3010 {lab=GNDA}
N 2790 -3070 2840 -3070 {lab=GNDA}
N 2790 -3200 2790 -3100 {lab=Vb7}
N 2680 -3070 2750 -3070 {lab=nfet_gate_10uA}
N 6610 -3010 6660 -3010 {lab=VDD_PSRR}
N 6660 -3070 6660 -3010 {lab=VDD_PSRR}
N 6610 -3070 6660 -3070 {lab=VDD_PSRR}
N 6510 -3010 6570 -3010 {lab=pfet_gate_10uA}
N 4960 -2370 5010 -2370 {lab=VDDA}
N 5010 -2430 5010 -2370 {lab=VDDA}
N 4960 -2430 5010 -2430 {lab=VDDA}
N 4830 -2370 4920 -2370 {lab=pfet_gate_10uA}
N 8810 -1670 8860 -1670 {lab=GNDA}
N 8860 -1730 8860 -1670 {lab=GNDA}
N 8810 -1730 8860 -1730 {lab=GNDA}
N 8700 -1730 8770 -1730 {lab=nfet_gate_10uA}
N 10760 -2160 10760 -2100 {lab=GNDA}
N 10710 -2160 10760 -2160 {lab=GNDA}
N 10600 -2160 10670 -2160 {lab=nfet_gate_10uA}
N 10710 -2700 10760 -2700 {lab=VDD_PSRR}
N 10760 -2760 10760 -2700 {lab=VDD_PSRR}
N 10610 -2700 10670 -2700 {lab=pfet_gate_10uA}
N 11250 -2700 11300 -2700 {lab=VDD_PSRR}
N 11250 -2760 11250 -2700 {lab=VDD_PSRR}
N 11340 -2700 11400 -2700 {lab=pfet_gate_10uA}
N 11250 -2160 11250 -2100 {lab=GNDA}
N 11250 -2160 11300 -2160 {lab=GNDA}
N 11340 -2160 11410 -2160 {lab=nfet_gate_10uA}
N 6140 -1800 6140 -1740 {lab=VIN-}
N 7190 -1800 7190 -1740 {lab=VIN+}
N 14300 -2890 14300 -2810 {lab=Y}
N 13870 -2890 13870 -2810 {lab=X}
N 14480 -2660 14620 -2660 {lab=VOUT+}
N 13550 -2660 13690 -2660 {lab=VOUT-}
N 14300 -2750 14300 -2660 {lab=#net1}
N 13870 -2750 13870 -2660 {lab=#net2}
N 13750 -2660 13870 -2660 {lab=#net2}
N 14300 -2660 14420 -2660 {lab=#net1}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7080 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6330 -2410 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7040 -2410 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6330 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7040 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6330 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7040 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6480 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb7}
C {lab_wire.sym} 6480 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb6}
C {sky130_fd_pr/nfet_01v8.sym} 6590 -1540 0 0 {name=M15
W=45
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4980 -1540 0 1 {name=M16
W=5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4780 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5150 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6590 -1950 0 0 {name=M19
W=1
L=1.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 6310 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {lab_pin.sym} 7060 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 10690 -2260 0 0 {name=M25
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10690 -2600 0 0 {name=M26
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 10470 -2440 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 11530 -2440 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10890 -2650 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 10890 -2210 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11120 -2650 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 11120 -2210 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_wire.sym} 11010 -2440 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 11320 -2260 0 1 {name=M27
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11320 -2600 0 1 {name=M28
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9950 -1800 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9670 -1800 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9910 -1440 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9710 -1440 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10050 -1800 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 9790 -2190 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8670 -1970 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8950 -1970 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 9060 -1970 0 1 {name=p34 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 8560 -1970 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 8830 -2190 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 13570 -2190 0 1 {name=M37
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14600 -2190 0 0 {name=M38
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13570 -2890 0 1 {name=M39
W=59
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14600 -2890 0 0 {name=M40
W=59
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 13920 -2890 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 14250 -2890 0 0 {name=p46 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 13710 -2310 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14460 -2310 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 6930 -1540 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6610 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 6310 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 7060 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 6480 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6040 -1540 0 0 {name=p21 sig_type=std_logic lab=VGS9}
C {lab_wire.sym} 4960 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 6310 -3000 0 1 {name=p23 sig_type=std_logic lab=VD7}
C {lab_pin.sym} 7060 -3000 0 0 {name=p57 sig_type=std_logic lab=VD6}
C {lab_pin.sym} 9930 -1540 0 1 {name=p33 sig_type=std_logic lab=err_opamp_mir}
C {lab_wire.sym} 9770 -1900 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 8850 -2070 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 9460 -2190 0 1 {name=p39 sig_type=std_logic lab=V_gate}
C {lab_wire.sym} 9530 -1540 2 1 {name=p40 sig_type=std_logic lab=err_opamp_out}
C {lab_wire.sym} 11420 -2210 0 1 {name=p44 sig_type=std_logic lab=V_2}
C {lab_wire.sym} 11390 -2650 0 1 {name=p41 sig_type=std_logic lab=V_1}
C {lab_wire.sym} 14090 -2190 0 0 {name=p43 sig_type=std_logic lab=V_b}
C {lab_wire.sym} 6480 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {sky130_fd_pr/pfet_01v8.sym} 2030 -3450 0 1 {name=M5
W=0.63
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2810 -3350 0 1 {name=M6
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2810 -3560 0 1 {name=M43
W=3.2
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2910 -3560 0 1 {name=p6 sig_type=std_logic lab=Vb7}
C {lab_pin.sym} 2130 -3450 0 1 {name=p7 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2990 -3350 0 1 {name=p8 sig_type=std_logic lab=Vb6}
C {lab_pin.sym} 2790 -3470 0 1 {name=p12 sig_type=std_logic lab=V5}
C {lab_wire.sym} 10590 -2210 0 0 {name=p14 sig_type=std_logic lab=V_4}
C {lab_wire.sym} 10620 -2650 0 0 {name=p56 sig_type=std_logic lab=V_3}
C {sky130_fd_pr/pfet_01v8.sym} 2360 -2010 0 0 {name=M42
W=1
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1990 -3080 0 0 {name=M44
W=1
L=0.5
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2550 -1550 0 1 {name=p60 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 1900 -3080 0 0 {name=p61 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 2770 -3070 0 0 {name=M45
W=1
L=0.5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2680 -3070 0 0 {name=p62 sig_type=std_logic lab=nfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 6590 -3010 0 0 {name=M50
W=1
L=0.5
nf=1
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 6510 -3010 0 0 {name=p67 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/pfet_01v8.sym} 4940 -2370 0 0 {name=M51
W=1
L=0.5
nf=1
mult=9
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8790 -1730 0 0 {name=M53
W=1
L=0.5
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8700 -1730 0 0 {name=p70 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 10610 -2700 0 0 {name=p72 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 11400 -2700 0 1 {name=p73 sig_type=std_logic lab=pfet_gate_10uA}
C {lab_wire.sym} 5160 -2070 0 1 {name=p75 sig_type=std_logic lab=VGS9}
C {sky130_fd_pr/nfet_01v8.sym} 10690 -2160 0 0 {name=M54
W=1
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 11320 -2160 0 1 {name=M55
W=1
L=0.5
nf=1 
mult=3
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 10690 -2700 0 0 {name=M56
W=1
L=0.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11320 -2700 0 1 {name=M57
W=1
L=0.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10600 -2160 0 0 {name=p85 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 11410 -2160 0 1 {name=p71 sig_type=std_logic lab=nfet_gate_10uA}
C {lab_wire.sym} 4830 -2370 0 0 {name=p74 sig_type=std_logic lab=pfet_gate_10uA}
C {sky130_fd_pr/nfet_01v8.sym} 2400 -1550 0 1 {name=M20
W=1
L=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {iopin.sym} 4960 -2500 0 0 {name=p1 lab=VDDA
}
C {ipin.sym} 9560 -1800 0 0 {name=p2 lab=V_err_amp_ref}
C {iopin.sym} 6610 -1360 0 0 {name=p3 lab=GNDA
}
C {ipin.sym} 6140 -1670 0 0 {name=p4 lab=VIN-}
C {ipin.sym} 7190 -1670 0 1 {name=p5 lab=VIN+}
C {lab_wire.sym} 13550 -3040 0 1 {name=p18 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 14620 -3040 0 1 {name=p19 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 2370 -3800 0 1 {name=p20 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 2380 -2150 0 1 {name=p28 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 8810 -2340 0 1 {name=p29 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 9810 -2340 0 1 {name=p30 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 10710 -2810 0 1 {name=p31 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 11300 -2810 0 1 {name=p49 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 10710 -2340 0 1 {name=p50 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 11300 -2340 0 1 {name=p51 sig_type=std_logic lab=VDD_PSRR}
C {lab_wire.sym} 2010 -2960 2 0 {name=p52 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 2790 -2960 2 0 {name=p53 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 13550 -1990 2 0 {name=p54 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14620 -1990 2 0 {name=p55 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 2380 -1430 2 0 {name=p58 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 4960 -1390 2 0 {name=p63 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 8810 -1630 2 0 {name=p64 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 9810 -1310 2 0 {name=p65 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 10890 -2190 2 0 {name=p66 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 10710 -2070 2 0 {name=p68 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 11300 -2070 2 0 {name=p69 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 10710 -2520 2 0 {name=p76 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 11300 -2520 2 0 {name=p77 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 10890 -2670 0 1 {name=p78 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 11120 -2670 0 1 {name=p79 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 13710 -2290 2 0 {name=p80 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14460 -2290 2 0 {name=p81 sig_type=std_logic lab=GNDA}
C {ipin.sym} 2250 -2010 0 0 {name=p84 lab=pfet_gate_10uA}
C {opin.sym} 14870 -2380 0 0 {name=p59 lab=VOUT+}
C {opin.sym} 13310 -2380 0 1 {name=p47 lab=VOUT-}
C {lab_wire.sym} 11120 -2190 2 0 {name=p48 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/cap_mim_m3_1.sym} 14300 -2780 0 0 {name=C6 model=cap_mim_m3_1 W=25 L=25 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 13870 -2780 0 1 {name=C7 model=cap_mim_m3_1 W=25 L=25 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_high_po.sym} 13720 -2660 3 0 {name=R29
W=1.19
L=1
model=res_high_po
spiceprefix=X
mult=1}
C {devices/gnd.sym} 13720 -2640 0 0 {name=l53 lab=GND}
C {sky130_fd_pr/res_high_po.sym} 14450 -2660 1 1 {name=R32
W=1.19
L=1
model=res_high_po
spiceprefix=X
mult=1}
C {devices/gnd.sym} 14450 -2640 0 1 {name=l54 lab=GND}
C {iopin.sym} 6490 -3400 0 0 {name=p82 lab=VDD_PSRR
}
