v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {N 30uA} 13770 -2810 0 0 1 1 {}
T {P 30uA} 13790 -3500 0 0 1 1 {}
T {P 30uA} 15890 -3500 0 1 1 1 {}
T {N 30uA} 15910 -2810 0 1 1 1 {}
T {1st stage pmos current source load voltage bias references} 1090 -4110 0 0 2 2 {}
T {1st stage} 9130 -4540 0 0 4 4 {}
T {1st gain stage} 8080 -3840 0 0 2 2 {}
T {1st stage CMFB} 12670 -3920 0 0 2 2 {}
T {2nd stage} 18110 -4340 0 0 4 4 {}
N 8040 -1770 8040 -1680 {lab=V_p}
N 8040 -1680 8790 -1680 {lab=V_p}
N 8790 -1770 8790 -1680 {lab=V_p}
N 8040 -2380 8040 -1830 {lab=VD1}
N 8790 -2380 8790 -1830 {lab=VD2}
N 8080 -2410 8750 -2410 {lab=Vb1}
N 8040 -2740 8040 -2440 {lab=X}
N 8790 -2740 8790 -2440 {lab=Y}
N 8040 -3160 8040 -2800 {lab=VD3}
N 8790 -3160 8790 -2800 {lab=VD4}
N 8080 -2770 8750 -2770 {lab=Vb2}
N 8790 -2770 8860 -2770 {lab=VD4}
N 8860 -2840 8860 -2770 {lab=VD4}
N 8790 -2840 8860 -2840 {lab=VD4}
N 7970 -2770 8040 -2770 {lab=VD3}
N 7970 -2840 7970 -2770 {lab=VD3}
N 7970 -2840 8040 -2840 {lab=VD3}
N 8040 -3340 8040 -3220 {lab=VDDA}
N 8790 -3340 8790 -3220 {lab=VDDA}
N 8080 -3190 8750 -3190 {lab=Vb3}
N 8790 -3190 8860 -3190 {lab=VDDA}
N 8860 -3260 8860 -3190 {lab=VDDA}
N 8790 -3260 8860 -3260 {lab=VDDA}
N 7970 -3190 8040 -3190 {lab=VDDA}
N 7970 -3260 7970 -3190 {lab=VDDA}
N 7970 -3260 8040 -3260 {lab=VDDA}
N 8040 -3340 8790 -3340 {lab=VDDA}
N 7990 -2410 8040 -2410 {lab=GNDA}
N 7990 -2410 7990 -2350 {lab=GNDA}
N 7990 -2350 8850 -2350 {lab=GNDA}
N 8850 -2410 8850 -2350 {lab=GNDA}
N 8790 -2410 8850 -2410 {lab=GNDA}
N 8220 -3400 8220 -3340 {lab=VDDA}
N 8490 -1800 8790 -1800 {lab=GNDA}
N 8040 -1800 8490 -1800 {lab=GNDA}
N 8340 -1680 8340 -1570 {lab=V_p}
N 8490 -1800 8490 -1540 {lab=GNDA}
N 8340 -1540 8490 -1540 {lab=GNDA}
N 8340 -1510 8340 -1020 {lab=GNDA}
N 8340 -1460 8490 -1460 {lab=GNDA}
N 8490 -1540 8490 -1460 {lab=GNDA}
N 8830 -1800 8920 -1800 {lab=VIN+}
N 6230 -1680 6230 -1570 {lab=V_p_mir}
N 6150 -1540 6230 -1540 {lab=GNDA}
N 6230 -1510 6230 -1300 {lab=GNDA}
N 6150 -1460 6230 -1460 {lab=GNDA}
N 6150 -1540 6150 -1460 {lab=GNDA}
N 6270 -1540 8300 -1540 {lab=V_tail_gate}
N 6310 -1800 6400 -1800 {lab=GNDA}
N 6070 -1800 6310 -1800 {lab=GNDA}
N 6070 -1770 6070 -1680 {lab=V_p_mir}
N 6070 -1680 6400 -1680 {lab=V_p_mir}
N 6400 -1770 6400 -1680 {lab=V_p_mir}
N 6150 -1800 6150 -1540 {lab=GNDA}
N 6070 -1950 6070 -1830 {lab=V_tail_gate}
N 6070 -1950 6400 -1950 {lab=V_tail_gate}
N 6400 -1950 6400 -1830 {lab=V_tail_gate}
N 6230 -2150 6230 -1950 {lab=V_tail_gate}
N 6440 -1800 6510 -1800 {lab=VIN-}
N 5960 -1800 6030 -1800 {lab=VIN+}
N 6230 -2070 6800 -2070 {lab=V_tail_gate}
N 6800 -2070 6800 -1540 {lab=V_tail_gate}
N 8340 -2060 8340 -1980 {lab=Vb1}
N 8340 -1950 8490 -1950 {lab=GNDA}
N 8340 -1920 8340 -1680 {lab=V_p}
N 8340 -2410 8340 -2120 {lab=Vb1}
N 8210 -1950 8300 -1950 {lab=Vb1}
N 8210 -2210 8210 -1950 {lab=Vb1}
N 8210 -2210 8340 -2210 {lab=Vb1}
N 8340 -2980 8340 -2410 {lab=Vb1}
N 14060 -3030 14060 -2980 {lab=VDDA}
N 14060 -2820 14060 -2760 {lab=GNDA}
N 14060 -2920 14060 -2880 {lab=V_CMFB_S2}
N 14060 -3260 14060 -3210 {lab=GNDA}
N 14060 -3370 14060 -3320 {lab=V_CMFB_S1}
N 13940 -3290 13940 -2950 {lab=X}
N 15660 -3290 15730 -3290 {lab=Y}
N 15730 -3290 15730 -2950 {lab=Y}
N 15660 -2950 15730 -2950 {lab=Y}
N 13820 -3130 13940 -3130 {lab=X}
N 15730 -3130 15850 -3130 {lab=Y}
N 14990 -3340 15620 -3340 {lab=V_CMFB_S3}
N 14990 -2900 15620 -2900 {lab=V_CMFB_S4}
N 14060 -3290 14140 -3290 {lab=VDDA}
N 14060 -3450 14140 -3450 {lab=VDDA}
N 14060 -3500 14060 -3420 {lab=VDDA}
N 14140 -3450 14140 -3290 {lab=VDDA}
N 14060 -2790 14140 -2790 {lab=GNDA}
N 14060 -2950 14140 -2950 {lab=GNDA}
N 14140 -2950 14140 -2790 {lab=GNDA}
N 15620 -3030 15620 -2980 {lab=VDDA}
N 15620 -2820 15620 -2760 {lab=GNDA}
N 15620 -2920 15620 -2880 {lab=V_CMFB_S4}
N 15620 -3260 15620 -3210 {lab=GNDA}
N 15620 -3370 15620 -3320 {lab=V_CMFB_S3}
N 15540 -3290 15620 -3290 {lab=VDDA}
N 15540 -3450 15620 -3450 {lab=VDDA}
N 15620 -3500 15620 -3420 {lab=VDDA}
N 15540 -3450 15540 -3290 {lab=VDDA}
N 15540 -2790 15620 -2790 {lab=GNDA}
N 15540 -2950 15620 -2950 {lab=GNDA}
N 15540 -2950 15540 -2790 {lab=GNDA}
N 14830 -3340 14830 -2900 {lab=V_tot}
N 12800 -2330 12800 -2260 {lab=V_err_p}
N 12560 -2330 12800 -2330 {lab=V_err_p}
N 12560 -2330 12560 -2260 {lab=V_err_p}
N 12680 -2590 12680 -2330 {lab=V_err_p}
N 12680 -2900 12680 -2650 {lab=VDDA}
N 12800 -2200 12800 -1340 {lab=err_amp_mir}
N 12560 -2200 12560 -1340 {lab=err_amp_out}
N 12800 -1280 12800 -1200 {lab=GNDA}
N 12560 -1200 12800 -1200 {lab=GNDA}
N 12560 -1280 12560 -1200 {lab=GNDA}
N 12680 -1200 12680 -1150 {lab=GNDA}
N 12560 -2230 12800 -2230 {lab=VDDA}
N 12600 -1310 12760 -1310 {lab=err_amp_mir}
N 12520 -1310 12560 -1310 {lab=GNDA}
N 12520 -1310 12520 -1260 {lab=GNDA}
N 12520 -1260 12560 -1260 {lab=GNDA}
N 12800 -1310 12840 -1310 {lab=GNDA}
N 12840 -1310 12840 -1260 {lab=GNDA}
N 12800 -1260 12840 -1260 {lab=GNDA}
N 12700 -1390 12800 -1390 {lab=err_amp_mir}
N 12700 -1390 12700 -1310 {lab=err_amp_mir}
N 14830 -2900 14830 -2230 {lab=V_tot}
N 12430 -2230 12520 -2230 {lab=V_err_amp_ref}
N 8490 -1540 8640 -1540 {lab=GNDA}
N 8490 -1460 8640 -1460 {lab=GNDA}
N 8640 -1510 8640 -1460 {lab=GNDA}
N 8640 -1680 8640 -1570 {lab=V_p}
N 12840 -2230 14830 -2230 {lab=V_tot}
N 12680 -2620 12720 -2620 {lab=VDDA}
N 12720 -2680 12720 -2620 {lab=VDDA}
N 12680 -2680 12720 -2680 {lab=VDDA}
N 12720 -2620 12720 -2230 {lab=VDDA}
N 11260 -2500 11260 -2430 {lab=V_err_mir_p}
N 11260 -2500 11500 -2500 {lab=V_err_mir_p}
N 11500 -2500 11500 -2430 {lab=V_err_mir_p}
N 11380 -2590 11380 -2500 {lab=V_err_mir_p}
N 11380 -2900 11380 -2650 {lab=VDDA}
N 11260 -2400 11500 -2400 {lab=VDDA}
N 11540 -2400 11630 -2400 {lab=V_err_amp_ref}
N 11340 -2620 11380 -2620 {lab=VDDA}
N 11340 -2680 11340 -2620 {lab=VDDA}
N 11340 -2680 11380 -2680 {lab=VDDA}
N 11340 -2620 11340 -2400 {lab=VDDA}
N 11420 -2620 12640 -2620 {lab=V_err_gate}
N 11260 -2370 11260 -2310 {lab=V_err_gate}
N 11260 -2310 11500 -2310 {lab=V_err_gate}
N 11500 -2370 11500 -2310 {lab=V_err_gate}
N 11380 -2310 11380 -2070 {lab=V_err_gate}
N 11130 -2400 11220 -2400 {lab=V_tot}
N 11830 -2620 11830 -2250 {lab=V_err_gate}
N 11380 -2250 11830 -2250 {lab=V_err_gate}
N 8680 -1540 12410 -1540 {lab=err_amp_out}
N 12410 -1540 12560 -1540 {lab=err_amp_out}
N 8490 -2090 8490 -1800 {lab=GNDA}
N 8490 -2350 8490 -2090 {lab=GNDA}
N 18130 -2860 18130 -2220 {lab=VOUT-}
N 19200 -2860 19200 -2220 {lab=VOUT+}
N 19200 -2890 19270 -2890 {lab=VDDA}
N 19270 -2960 19270 -2890 {lab=VDDA}
N 19200 -2960 19270 -2960 {lab=VDDA}
N 18060 -2890 18130 -2890 {lab=VDDA}
N 18060 -2960 18130 -2960 {lab=VDDA}
N 18060 -2960 18060 -2890 {lab=VDDA}
N 18130 -3040 18130 -2920 {lab=VDDA}
N 19200 -3040 19200 -2920 {lab=VDDA}
N 18130 -2160 18130 -1990 {lab=GNDA}
N 19200 -2160 19200 -1990 {lab=GNDA}
N 19200 -2120 19270 -2120 {lab=GNDA}
N 19270 -2190 19270 -2120 {lab=GNDA}
N 19200 -2190 19270 -2190 {lab=GNDA}
N 18060 -2120 18130 -2120 {lab=GNDA}
N 18060 -2190 18130 -2190 {lab=GNDA}
N 18060 -2190 18060 -2120 {lab=GNDA}
N 18170 -2890 18500 -2890 {lab=X}
N 18830 -2890 19160 -2890 {lab=Y}
N 17890 -2500 18130 -2500 {lab=VOUT-}
N 19200 -2500 19450 -2500 {lab=VOUT+}
N 19070 -2310 19200 -2310 {lab=VOUT+}
N 18670 -2190 19160 -2190 {lab=V_b_2nd_stage}
N 18730 -2310 19010 -2310 {lab=V_b_2nd_stage}
N 18730 -2310 18730 -2190 {lab=V_b_2nd_stage}
N 18130 -2310 18260 -2310 {lab=VOUT-}
N 18320 -2310 18610 -2310 {lab=V_b_2nd_stage}
N 18170 -2190 18670 -2190 {lab=V_b_2nd_stage}
N 18610 -2310 18610 -2190 {lab=V_b_2nd_stage}
N 14730 -2900 14930 -2900 {lab=V_tot}
N 14730 -3340 14930 -3340 {lab=V_tot}
N 14060 -3340 14670 -3340 {lab=V_CMFB_S1}
N 14060 -2900 14670 -2900 {lab=V_CMFB_S2}
N 13940 -3290 14020 -3290 {lab=X}
N 13940 -2950 14020 -2950 {lab=X}
N 7870 -1800 8000 -1800 {lab=VIN-}
N 15620 -2900 15740 -2900 {lab=V_CMFB_S4}
N 15620 -3340 15730 -3340 {lab=V_CMFB_S3}
N 8040 -1680 8790 -1680 {lab=V_p}
N 7060 -1800 7870 -1800 {lab=VIN-}
N 6510 -1800 7060 -1800 {lab=VIN-}
N 5960 -1900 7060 -1900 {lab=VIN+}
N 5960 -1900 5960 -1800 {lab=VIN+}
N 8920 -1900 8920 -1800 {lab=VIN+}
N 7060 -1900 8920 -1900 {lab=VIN+}
N 7870 -1740 7870 -1670 {lab=VIN-}
N 8920 -1740 8920 -1670 {lab=VIN+}
N 6230 -2340 6230 -2150 {lab=V_tail_gate}
N 8340 -2120 8340 -2060 {lab=Vb1}
N 13940 -2900 14060 -2900 {lab=V_CMFB_S2}
N 13940 -3340 14060 -3340 {lab=V_CMFB_S1}
N 7870 -1800 7870 -1740 {lab=VIN-}
N 8920 -1800 8920 -1740 {lab=VIN+}
N 18880 -2890 18880 -2810 {lab=Y}
N 18450 -2890 18450 -2810 {lab=X}
N 19060 -2660 19200 -2660 {lab=VOUT+}
N 18130 -2660 18270 -2660 {lab=VOUT-}
N 18880 -2750 18880 -2660 {lab=cap_res_Y}
N 18450 -2750 18450 -2660 {lab=cap_res_X}
N 18330 -2660 18450 -2660 {lab=cap_res_X}
N 18880 -2660 19000 -2660 {lab=cap_res_Y}
N 6400 -1370 6400 -1340 {lab=GNDA}
N 6320 -1400 6400 -1400 {lab=GNDA}
N 6320 -1400 6320 -1340 {lab=GNDA}
N 6230 -1340 6400 -1340 {lab=GNDA}
N 6400 -1460 6400 -1430 {lab=GNDA}
N 6230 -1460 6400 -1460 {lab=GNDA}
N 6440 -1400 6480 -1400 {lab=GNDA}
N 6480 -1400 6480 -1340 {lab=GNDA}
N 6400 -1340 6480 -1340 {lab=GNDA}
N 8880 -1290 8880 -1110 {lab=GNDA}
N 8340 -1110 8880 -1110 {lab=GNDA}
N 8780 -1320 8880 -1320 {lab=GNDA}
N 8780 -1320 8780 -1110 {lab=GNDA}
N 8920 -1320 9000 -1320 {lab=GNDA}
N 9000 -1320 9000 -1110 {lab=GNDA}
N 8880 -1110 9000 -1110 {lab=GNDA}
N 8880 -1630 8880 -1350 {lab=V_p}
N 8640 -1630 8880 -1630 {lab=V_p}
N 5610 -1800 5740 -1800 {lab=GNDA}
N 5610 -1950 5610 -1830 {lab=V_tail_gate}
N 5610 -1950 6070 -1950 {lab=V_tail_gate}
N 5470 -1800 5570 -1800 {lab=GNDA}
N 5470 -1800 5470 -1710 {lab=GNDA}
N 5470 -1710 5610 -1710 {lab=GNDA}
N 5610 -1540 6150 -1540 {lab=GNDA}
N 5610 -1770 5610 -1540 {lab=GNDA}
N 5740 -1800 5740 -1540 {lab=GNDA}
N 7390 -1300 7460 -1300 {lab=GNDA}
N 7390 -1300 7390 -1210 {lab=GNDA}
N 7390 -1210 7500 -1210 {lab=GNDA}
N 7500 -2000 7500 -1330 {lab=VD1}
N 9370 -1300 9440 -1300 {lab=GNDA}
N 9440 -1300 9440 -1210 {lab=GNDA}
N 9330 -1210 9440 -1210 {lab=GNDA}
N 9330 -2000 9330 -1330 {lab=VD2}
N 7500 -1270 7500 -1110 {lab=GNDA}
N 9330 -1270 9330 -1110 {lab=GNDA}
N 9000 -1110 9330 -1110 {lab=GNDA}
N 8790 -2000 9330 -2000 {lab=VD2}
N 7500 -2000 8040 -2000 {lab=VD1}
N 7500 -1110 8340 -1110 {lab=GNDA}
N 9170 -2410 9240 -2410 {lab=GNDA}
N 9240 -2410 9240 -2320 {lab=GNDA}
N 9130 -2320 9240 -2320 {lab=GNDA}
N 9130 -2380 9130 -2230 {lab=GNDA}
N 9130 -2530 9130 -2440 {lab=Y}
N 8790 -2530 9130 -2530 {lab=Y}
N 9025 -2410 9130 -2410 {lab=GNDA}
N 9025 -2410 9025 -2320 {lab=GNDA}
N 9025 -2320 9130 -2320 {lab=GNDA}
N 7700 -3190 7830 -3190 {lab=VDDA}
N 7830 -3280 7830 -3190 {lab=VDDA}
N 7700 -3280 7830 -3280 {lab=VDDA}
N 7700 -3280 7700 -3220 {lab=VDDA}
N 7570 -3280 7570 -3190 {lab=VDDA}
N 7570 -3280 7700 -3280 {lab=VDDA}
N 7570 -3190 7660 -3190 {lab=VDDA}
N 7700 -3340 8040 -3340 {lab=VDDA}
N 7700 -3340 7700 -3280 {lab=VDDA}
N 7700 -3160 7700 -3100 {lab=VD3}
N 7700 -3100 8040 -3100 {lab=VD3}
N 9000 -2770 9130 -2770 {lab=VD4}
N 9000 -2860 9000 -2770 {lab=VD4}
N 9000 -2860 9130 -2860 {lab=VD4}
N 9130 -2860 9130 -2800 {lab=VD4}
N 9260 -2860 9260 -2770 {lab=VD4}
N 9130 -2860 9260 -2860 {lab=VD4}
N 9170 -2770 9260 -2770 {lab=VD4}
N 8790 -2920 9130 -2920 {lab=VD4}
N 9130 -2920 9130 -2860 {lab=VD4}
N 9130 -2740 9130 -2680 {lab=Y}
N 8790 -2680 9130 -2680 {lab=Y}
N 7700 -2770 7830 -2770 {lab=VD3}
N 7830 -2860 7830 -2770 {lab=VD3}
N 7700 -2860 7830 -2860 {lab=VD3}
N 7700 -2860 7700 -2800 {lab=VD3}
N 7570 -2860 7570 -2770 {lab=VD3}
N 7570 -2860 7700 -2860 {lab=VD3}
N 7570 -2770 7660 -2770 {lab=VD3}
N 7700 -2920 8040 -2920 {lab=VD3}
N 7700 -2920 7700 -2860 {lab=VD3}
N 7700 -2740 7700 -2680 {lab=X}
N 7700 -2680 8040 -2680 {lab=X}
N 13030 -2620 13100 -2620 {lab=VDDA}
N 13100 -2710 13100 -2620 {lab=VDDA}
N 12990 -2710 13100 -2710 {lab=VDDA}
N 12990 -2710 12990 -2650 {lab=VDDA}
N 12880 -2710 12990 -2710 {lab=VDDA}
N 12880 -2710 12880 -2620 {lab=VDDA}
N 12880 -2620 12990 -2620 {lab=VDDA}
N 12990 -2590 12990 -2550 {lab=V_err_p}
N 12680 -2550 12990 -2550 {lab=V_err_p}
N 12990 -2750 12990 -2710 {lab=VDDA}
N 12680 -2750 12990 -2750 {lab=VDDA}
N 12160 -1900 12230 -1900 {lab=VDDA}
N 12160 -1990 12160 -1900 {lab=VDDA}
N 12160 -1990 12270 -1990 {lab=VDDA}
N 12270 -1990 12270 -1930 {lab=VDDA}
N 12270 -1990 12380 -1990 {lab=VDDA}
N 12380 -1990 12380 -1900 {lab=VDDA}
N 12270 -1900 12380 -1900 {lab=VDDA}
N 12270 -1870 12270 -1820 {lab=err_amp_out}
N 12270 -2030 12270 -1990 {lab=VDDA}
N 10780 -2400 10850 -2400 {lab=VDDA}
N 10780 -2490 10780 -2400 {lab=VDDA}
N 10780 -2490 10890 -2490 {lab=VDDA}
N 10890 -2490 10890 -2430 {lab=VDDA}
N 10890 -2490 11000 -2490 {lab=VDDA}
N 11000 -2490 11000 -2400 {lab=VDDA}
N 10890 -2400 11000 -2400 {lab=VDDA}
N 10890 -2530 10890 -2490 {lab=VDDA}
N 10890 -2310 11260 -2310 {lab=V_err_gate}
N 10890 -2370 10890 -2310 {lab=V_err_gate}
N 12270 -1820 12560 -1820 {lab=err_amp_out}
N 13130 -1900 13200 -1900 {lab=VDDA}
N 13200 -1990 13200 -1900 {lab=VDDA}
N 13090 -1990 13200 -1990 {lab=VDDA}
N 13090 -1990 13090 -1930 {lab=VDDA}
N 12980 -1990 13090 -1990 {lab=VDDA}
N 12980 -1990 12980 -1900 {lab=VDDA}
N 12980 -1900 13090 -1900 {lab=VDDA}
N 13090 -1870 13090 -1820 {lab=err_amp_mir}
N 13090 -2030 13090 -1990 {lab=VDDA}
N 12800 -1820 13090 -1820 {lab=err_amp_mir}
N 14300 -3390 14390 -3390 {lab=VDDA}
N 14430 -3390 14480 -3390 {lab=VDDA}
N 14140 -3450 14390 -3450 {lab=VDDA}
N 14390 -3450 14390 -3420 {lab=VDDA}
N 14480 -3450 14480 -3390 {lab=VDDA}
N 14390 -3450 14480 -3450 {lab=VDDA}
N 14300 -3450 14300 -3390 {lab=VDDA}
N 14390 -3360 14390 -3240 {lab=GNDA}
N 14060 -3240 14390 -3240 {lab=GNDA}
N 15270 -3390 15360 -3390 {lab=VDDA}
N 15180 -3390 15230 -3390 {lab=VDDA}
N 15270 -3450 15540 -3450 {lab=VDDA}
N 15270 -3450 15270 -3420 {lab=VDDA}
N 15180 -3450 15180 -3390 {lab=VDDA}
N 15180 -3450 15270 -3450 {lab=VDDA}
N 15360 -3450 15360 -3390 {lab=VDDA}
N 15270 -3360 15270 -3240 {lab=GNDA}
N 15270 -3240 15620 -3240 {lab=GNDA}
N 15270 -2850 15360 -2850 {lab=GNDA}
N 15180 -2850 15230 -2850 {lab=GNDA}
N 15270 -2790 15540 -2790 {lab=GNDA}
N 15270 -2820 15270 -2790 {lab=GNDA}
N 15180 -2850 15180 -2790 {lab=GNDA}
N 15180 -2790 15270 -2790 {lab=GNDA}
N 15360 -2850 15360 -2790 {lab=GNDA}
N 15270 -3000 15270 -2880 {lab=VDDA}
N 15270 -3000 15620 -3000 {lab=VDDA}
N 14300 -2850 14390 -2850 {lab=GNDA}
N 14430 -2850 14480 -2850 {lab=GNDA}
N 14140 -2790 14390 -2790 {lab=GNDA}
N 14390 -2820 14390 -2790 {lab=GNDA}
N 14480 -2850 14480 -2790 {lab=GNDA}
N 14390 -2790 14480 -2790 {lab=GNDA}
N 14300 -2850 14300 -2790 {lab=GNDA}
N 14390 -3000 14390 -2880 {lab=VDDA}
N 14060 -3000 14390 -3000 {lab=VDDA}
N 19420 -2120 19490 -2120 {lab=GNDA}
N 19420 -2190 19420 -2120 {lab=GNDA}
N 19420 -2190 19490 -2190 {lab=GNDA}
N 19490 -2160 19490 -2050 {lab=GNDA}
N 19200 -2050 19490 -2050 {lab=GNDA}
N 17820 -2890 17890 -2890 {lab=VDDA}
N 17890 -2960 17890 -2890 {lab=VDDA}
N 17820 -2960 17890 -2960 {lab=VDDA}
N 17820 -2960 17820 -2920 {lab=VDDA}
N 17720 -2890 17780 -2890 {lab=VDDA}
N 17720 -2960 17720 -2890 {lab=VDDA}
N 17720 -2960 17820 -2960 {lab=VDDA}
N 17820 -3000 17820 -2960 {lab=VDDA}
N 17820 -3000 18130 -3000 {lab=VDDA}
N 19530 -2190 19590 -2190 {lab=GNDA}
N 19590 -2190 19590 -2120 {lab=GNDA}
N 19490 -2120 19590 -2120 {lab=GNDA}
N 19490 -2260 19490 -2220 {lab=VOUT+}
N 19200 -2260 19490 -2260 {lab=VOUT+}
N 17840 -2120 17910 -2120 {lab=GNDA}
N 17910 -2190 17910 -2120 {lab=GNDA}
N 17840 -2190 17910 -2190 {lab=GNDA}
N 17840 -2160 17840 -2050 {lab=GNDA}
N 17840 -2050 18130 -2050 {lab=GNDA}
N 17740 -2190 17800 -2190 {lab=GNDA}
N 17740 -2190 17740 -2120 {lab=GNDA}
N 17740 -2120 17840 -2120 {lab=GNDA}
N 17840 -2260 17840 -2220 {lab=VOUT-}
N 17840 -2260 18130 -2260 {lab=VOUT-}
N 19440 -2890 19510 -2890 {lab=VDDA}
N 19440 -2960 19440 -2890 {lab=VDDA}
N 19440 -2960 19510 -2960 {lab=VDDA}
N 19510 -2960 19510 -2920 {lab=VDDA}
N 19510 -2860 19510 -2790 {lab=VOUT+}
N 19200 -2790 19510 -2790 {lab=VOUT+}
N 19550 -2890 19610 -2890 {lab=VDDA}
N 19610 -2960 19610 -2890 {lab=VDDA}
N 19510 -2960 19610 -2960 {lab=VDDA}
N 19510 -3000 19510 -2960 {lab=VDDA}
N 19200 -3000 19510 -3000 {lab=VDDA}
N 7500 -1300 7620 -1300 {lab=GNDA}
N 7620 -1300 7620 -1210 {lab=GNDA}
N 7500 -1210 7620 -1210 {lab=GNDA}
N 9210 -1300 9330 -1300 {lab=GNDA}
N 9210 -1300 9210 -1210 {lab=GNDA}
N 9210 -1210 9330 -1210 {lab=GNDA}
N 17820 -2860 17820 -2790 {lab=VOUT-}
N 17820 -2790 18130 -2790 {lab=VOUT-}
N 12990 -1310 13030 -1310 {lab=GNDA}
N 12990 -1310 12990 -1260 {lab=GNDA}
N 12990 -1260 13030 -1260 {lab=GNDA}
N 13030 -1280 13030 -1200 {lab=GNDA}
N 12800 -1200 13030 -1200 {lab=GNDA}
N 13070 -1310 13110 -1310 {lab=GNDA}
N 13110 -1310 13110 -1260 {lab=GNDA}
N 13030 -1260 13110 -1260 {lab=GNDA}
N 13030 -1390 13030 -1340 {lab=err_amp_mir}
N 12800 -1390 13030 -1390 {lab=err_amp_mir}
N 12330 -1310 12370 -1310 {lab=GNDA}
N 12370 -1310 12370 -1260 {lab=GNDA}
N 12330 -1260 12370 -1260 {lab=GNDA}
N 12330 -1280 12330 -1200 {lab=GNDA}
N 12330 -1200 12560 -1200 {lab=GNDA}
N 12250 -1310 12290 -1310 {lab=GNDA}
N 12250 -1310 12250 -1260 {lab=GNDA}
N 12250 -1260 12330 -1260 {lab=GNDA}
N 12330 -1390 12330 -1340 {lab=err_amp_out}
N 12330 -1390 12560 -1390 {lab=err_amp_out}
N 7590 -2410 7660 -2410 {lab=GNDA}
N 7590 -2410 7590 -2320 {lab=GNDA}
N 7590 -2320 7700 -2320 {lab=GNDA}
N 7700 -2380 7700 -2230 {lab=GNDA}
N 7700 -2530 7700 -2440 {lab=X}
N 7700 -2530 8040 -2530 {lab=X}
N 7700 -2410 7805 -2410 {lab=GNDA}
N 7805 -2410 7805 -2320 {lab=GNDA}
N 7700 -2320 7805 -2320 {lab=GNDA}
N 9000 -3190 9130 -3190 {lab=VDDA}
N 9000 -3280 9000 -3190 {lab=VDDA}
N 9000 -3280 9130 -3280 {lab=VDDA}
N 9130 -3280 9130 -3220 {lab=VDDA}
N 9260 -3280 9260 -3190 {lab=VDDA}
N 9130 -3280 9260 -3280 {lab=VDDA}
N 9170 -3190 9260 -3190 {lab=VDDA}
N 8790 -3340 9130 -3340 {lab=VDDA}
N 9130 -3340 9130 -3280 {lab=VDDA}
N 9130 -3160 9130 -3100 {lab=VD4}
N 8790 -3100 9130 -3100 {lab=VD4}
N 3280 -2740 3280 -1580 {lab=Vb2_Vb3}
N 3210 -1550 3280 -1550 {lab=Vb2_Vb3}
N 3210 -1620 3210 -1550 {lab=Vb2_Vb3}
N 3210 -1620 3280 -1620 {lab=Vb2_Vb3}
N 3280 -3650 3280 -2800 {lab=VDDA}
N 3210 -2770 3280 -2770 {lab=VDDA}
N 3210 -2840 3210 -2770 {lab=VDDA}
N 3210 -2840 3280 -2840 {lab=VDDA}
N 2310 -3740 2310 -3650 {lab=VDDA}
N 1230 -3650 3280 -3650 {lab=VDDA}
N 3320 -2770 3400 -2770 {lab=Vb3}
N 3400 -2770 3400 -1450 {lab=Vb3}
N 3280 -1450 3400 -1450 {lab=Vb3}
N 3320 -1550 3480 -1550 {lab=Vb2}
N 3650 -2770 3720 -2770 {lab=VDDA}
N 3650 -2840 3650 -2770 {lab=VDDA}
N 3650 -2840 3720 -2840 {lab=VDDA}
N 3720 -2880 3720 -2800 {lab=VDDA}
N 3280 -2880 3720 -2880 {lab=VDDA}
N 3760 -2770 3800 -2770 {lab=VDDA}
N 3800 -2820 3800 -2770 {lab=VDDA}
N 3720 -2820 3800 -2820 {lab=VDDA}
N 3280 -2640 3720 -2640 {lab=Vb2_Vb3}
N 3720 -2740 3720 -2640 {lab=Vb2_Vb3}
N 3650 -1550 3720 -1550 {lab=Vb2_Vb3}
N 3650 -1620 3650 -1550 {lab=Vb2_Vb3}
N 3650 -1620 3720 -1620 {lab=Vb2_Vb3}
N 3720 -1670 3720 -1580 {lab=Vb2_Vb3}
N 3760 -1550 3800 -1550 {lab=Vb2_Vb3}
N 3800 -1600 3800 -1550 {lab=Vb2_Vb3}
N 3720 -1600 3800 -1600 {lab=Vb2_Vb3}
N 3280 -1670 3720 -1670 {lab=Vb2_Vb3}
N 3720 -1520 3720 -1400 {lab=Vb3}
N 3280 -1410 3720 -1410 {lab=Vb3}
N 3280 -1520 3280 -960 {lab=Vb3}
N 1230 -2740 1230 -1580 {lab=Vb2_2}
N 1160 -1550 1230 -1550 {lab=Vb2_2}
N 1160 -1620 1160 -1550 {lab=Vb2_2}
N 1160 -1620 1230 -1620 {lab=Vb2_2}
N 1160 -2770 1230 -2770 {lab=VDDA}
N 1160 -2840 1160 -2770 {lab=VDDA}
N 1160 -2840 1230 -2840 {lab=VDDA}
N 1270 -2770 1350 -2770 {lab=Vb2}
N 1350 -2770 1350 -1450 {lab=Vb2}
N 1230 -1450 1350 -1450 {lab=Vb2}
N 1600 -2770 1670 -2770 {lab=VDDA}
N 1600 -2840 1600 -2770 {lab=VDDA}
N 1600 -2840 1670 -2840 {lab=VDDA}
N 1670 -2880 1670 -2800 {lab=VDDA}
N 1230 -2880 1670 -2880 {lab=VDDA}
N 1710 -2770 1750 -2770 {lab=VDDA}
N 1750 -2820 1750 -2770 {lab=VDDA}
N 1670 -2820 1750 -2820 {lab=VDDA}
N 1230 -2640 1670 -2640 {lab=Vb2_2}
N 1670 -2740 1670 -2640 {lab=Vb2_2}
N 1600 -1550 1670 -1550 {lab=Vb2_2}
N 1600 -1620 1600 -1550 {lab=Vb2_2}
N 1600 -1620 1670 -1620 {lab=Vb2_2}
N 1670 -1670 1670 -1580 {lab=Vb2_2}
N 1710 -1550 1750 -1550 {lab=Vb2_2}
N 1750 -1600 1750 -1550 {lab=Vb2_2}
N 1670 -1600 1750 -1600 {lab=Vb2_2}
N 1230 -1670 1670 -1670 {lab=Vb2_2}
N 1670 -1520 1670 -1400 {lab=Vb2}
N 1230 -1400 1670 -1400 {lab=Vb2}
N 1270 -1550 1350 -1550 {lab=Vb2}
N 1230 -3650 1230 -2800 {lab=VDDA}
N 1230 -1520 1230 -960 {lab=Vb2}
N 1350 -1550 1430 -1550 {lab=Vb2}
N 2840 -3350 2910 -3350 {lab=VDDA}
N 2910 -3420 2910 -3350 {lab=VDDA}
N 2840 -3420 2910 -3420 {lab=VDDA}
N 2840 -3460 2840 -3380 {lab=VDDA}
N 2760 -3350 2800 -3350 {lab=VDDA}
N 2760 -3400 2760 -3350 {lab=VDDA}
N 2760 -3400 2840 -3400 {lab=VDDA}
N 2840 -3320 2840 -3220 {lab=VDDA}
N 2840 -2130 2910 -2130 {lab=Vb2_Vb3}
N 2910 -2200 2910 -2130 {lab=Vb2_Vb3}
N 2840 -2200 2910 -2200 {lab=Vb2_Vb3}
N 2840 -2250 2840 -2160 {lab=Vb2_Vb3}
N 2760 -2130 2800 -2130 {lab=Vb2_Vb3}
N 2760 -2180 2760 -2130 {lab=Vb2_Vb3}
N 2760 -2180 2840 -2180 {lab=Vb2_Vb3}
N 2840 -2100 2840 -1980 {lab=Vb2_Vb3}
N 2840 -3460 3280 -3460 {lab=VDDA}
N 2840 -3220 3280 -3220 {lab=VDDA}
N 2840 -2250 3280 -2250 {lab=Vb2_Vb3}
N 2840 -1980 3280 -1980 {lab=Vb2_Vb3}
N 790 -3350 860 -3350 {lab=VDDA}
N 860 -3420 860 -3350 {lab=VDDA}
N 790 -3420 860 -3420 {lab=VDDA}
N 790 -3460 790 -3380 {lab=VDDA}
N 710 -3350 750 -3350 {lab=VDDA}
N 710 -3400 710 -3350 {lab=VDDA}
N 710 -3400 790 -3400 {lab=VDDA}
N 790 -3320 790 -3220 {lab=VDDA}
N 790 -2130 860 -2130 {lab=Vb2_2}
N 860 -2200 860 -2130 {lab=Vb2_2}
N 790 -2200 860 -2200 {lab=Vb2_2}
N 790 -2250 790 -2160 {lab=Vb2_2}
N 710 -2130 750 -2130 {lab=Vb2_2}
N 710 -2180 710 -2130 {lab=Vb2_2}
N 710 -2180 790 -2180 {lab=Vb2_2}
N 790 -2100 790 -1980 {lab=Vb2_2}
N 790 -3460 1230 -3460 {lab=VDDA}
N 790 -3220 1230 -3220 {lab=VDDA}
N 790 -2250 1230 -2250 {lab=Vb2_2}
N 790 -1980 1230 -1980 {lab=Vb2_2}
C {sky130_fd_pr/nfet_01v8.sym} 8020 -1800 0 0 {name=M7
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8810 -1800 0 1 {name=M8
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8060 -2410 0 1 {name=M9
W=15
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8770 -2410 0 0 {name=M10
W=15
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8060 -2770 0 1 {name=M11
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8770 -2770 0 0 {name=M12
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8060 -3190 0 1 {name=M13
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 8770 -3190 0 0 {name=M14
W=35
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8210 -3190 0 0 {name=p9 sig_type=std_logic lab=Vb3}
C {lab_wire.sym} 8210 -2770 0 0 {name=p10 sig_type=std_logic lab=Vb2}
C {sky130_fd_pr/nfet_01v8.sym} 8320 -1540 0 0 {name=M15
W=2.5
L=0.15
nf=1
mult=18
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6250 -1540 0 1 {name=M16
W=2.5
L=0.15
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6050 -1800 0 0 {name=M17
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6420 -1800 0 1 {name=M18
W=1.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8320 -1950 0 0 {name=M19
W=1
L=2.9
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 8040 -2600 0 0 {name=p16 sig_type=std_logic lab=X}
C {lab_pin.sym} 8790 -2600 0 1 {name=p24 sig_type=std_logic lab=Y}
C {sky130_fd_pr/nfet_01v8.sym} 14040 -2950 0 0 {name=M25
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 14040 -3290 0 0 {name=M26
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 13820 -3130 0 0 {name=p25 sig_type=std_logic lab=X}
C {lab_pin.sym} 15850 -3130 0 1 {name=p26 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14700 -3340 1 0 {name=R10
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14700 -2900 1 1 {name=R11
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14960 -3340 3 1 {name=R12
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 14960 -2900 3 0 {name=R13
L=3.5
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {lab_wire.sym} 14830 -3130 0 0 {name=p27 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/nfet_01v8.sym} 15640 -2950 0 1 {name=M27
W=30
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 15640 -3290 0 1 {name=M28
W=20
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12820 -2230 0 1 {name=M29
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12540 -2230 0 0 {name=M30
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12780 -1310 0 0 {name=M31
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12580 -1310 0 1 {name=M32
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 12920 -2230 0 1 {name=p32 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 12660 -2620 0 0 {name=M33
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11240 -2400 0 0 {name=M34
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 11520 -2400 0 1 {name=M35
W=2.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 11630 -2400 0 1 {name=p34 sig_type=std_logic lab=V_err_amp_ref}
C {lab_wire.sym} 11130 -2400 0 0 {name=p35 sig_type=std_logic lab=V_tot}
C {sky130_fd_pr/pfet_01v8.sym} 11400 -2620 0 1 {name=M36
W=5.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 18150 -2190 0 1 {name=M37
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 19180 -2190 0 0 {name=M38
W=28
L=0.6
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 18150 -2890 0 1 {name=M39
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19180 -2890 0 0 {name=M40
W=60
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 18500 -2890 0 1 {name=p45 sig_type=std_logic lab=X}
C {lab_pin.sym} 18830 -2890 0 0 {name=p46 sig_type=std_logic lab=Y}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 18290 -2310 1 1 {name=R22
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 19040 -2310 3 0 {name=R23
L=5.25
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 8660 -1540 0 1 {name=M41
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 8340 -1680 0 0 {name=p13 sig_type=std_logic lab=V_p}
C {lab_pin.sym} 8040 -2060 0 1 {name=p15 sig_type=std_logic lab=VD1}
C {lab_pin.sym} 8790 -2060 0 0 {name=p17 sig_type=std_logic lab=VD2}
C {lab_wire.sym} 8210 -1950 2 1 {name=p37 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 7770 -1540 0 0 {name=p21 sig_type=std_logic lab=V_tail_gate}
C {lab_wire.sym} 6230 -1680 0 1 {name=p22 sig_type=std_logic lab=V_p_mir}
C {lab_pin.sym} 8040 -3000 0 1 {name=p23 sig_type=std_logic lab=VD3}
C {lab_pin.sym} 8790 -3000 0 0 {name=p57 sig_type=std_logic lab=VD4}
C {lab_pin.sym} 12800 -1560 0 1 {name=p33 sig_type=std_logic lab=err_amp_mir}
C {lab_wire.sym} 12640 -2330 0 0 {name=p36 sig_type=std_logic lab=V_err_p}
C {lab_wire.sym} 11420 -2500 0 1 {name=p38 sig_type=std_logic lab=V_err_mir_p}
C {lab_wire.sym} 12020 -2620 0 1 {name=p39 sig_type=std_logic lab=V_err_gate}
C {lab_wire.sym} 12350 -1540 0 0 {name=p40 sig_type=std_logic lab=err_amp_out}
C {lab_wire.sym} 18670 -2190 2 0 {name=p43 sig_type=std_logic lab=V_b_2nd_stage}
C {lab_wire.sym} 8210 -2410 0 0 {name=p42 sig_type=std_logic lab=Vb1}
C {lab_wire.sym} 6430 -2070 0 1 {name=p75 sig_type=std_logic lab=V_tail_gate}
C {iopin.sym} 8220 -3400 0 0 {name=p1 lab=VDDA
}
C {ipin.sym} 12430 -2230 0 0 {name=p2 lab=V_err_amp_ref}
C {iopin.sym} 8340 -1020 0 0 {name=p3 lab=GNDA
}
C {ipin.sym} 7870 -1670 0 0 {name=p4 lab=VIN-}
C {ipin.sym} 8920 -1670 0 1 {name=p5 lab=VIN+}
C {lab_wire.sym} 18130 -3040 0 1 {name=p18 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 19200 -3040 0 1 {name=p19 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 11380 -2900 0 1 {name=p29 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 12680 -2900 0 1 {name=p30 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 14060 -3500 0 1 {name=p31 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 15620 -3500 0 1 {name=p49 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 14060 -3030 0 1 {name=p50 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 15620 -3030 0 1 {name=p51 sig_type=std_logic lab=VDDA}
C {lab_wire.sym} 18130 -1990 2 0 {name=p54 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 19200 -1990 2 0 {name=p55 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 6230 -1300 2 0 {name=p63 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 12680 -1150 2 0 {name=p65 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14700 -2880 2 0 {name=p66 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14060 -2760 2 0 {name=p68 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 15620 -2760 2 0 {name=p69 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14060 -3210 2 0 {name=p76 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 15620 -3210 2 0 {name=p77 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14700 -3360 0 1 {name=p78 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 14960 -3360 0 0 {name=p79 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 18290 -2290 2 0 {name=p80 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 19040 -2290 2 0 {name=p81 sig_type=std_logic lab=GNDA}
C {opin.sym} 19450 -2500 0 0 {name=p59 lab=VOUT+}
C {opin.sym} 17890 -2500 0 1 {name=p47 lab=VOUT-}
C {lab_wire.sym} 14960 -2880 2 1 {name=p48 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/cap_mim_m3_1.sym} 19030 -2660 1 1 {name=C6 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 18300 -2660 3 0 {name=C7 model=cap_mim_m3_1 W=2 L=2 MF=138 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 6420 -1400 0 1 {name=M21
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 8900 -1320 0 1 {name=M22
W=2.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5590 -1800 0 0 {name=M23
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 7480 -1300 0 0 {name=M24
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9350 -1300 0 1 {name=M46
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 9150 -2410 0 1 {name=M47
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7680 -3190 0 0 {name=M48
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -2770 0 1 {name=M49
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 7680 -2770 0 0 {name=M52
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 13010 -2620 0 1 {name=M58
W=1.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 12250 -1900 0 0 {name=M59
W=0.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 12270 -2030 0 0 {name=p83 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 10870 -2400 0 0 {name=M60
W=1.0
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 10890 -2530 0 0 {name=p86 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 13110 -1900 0 1 {name=M61
W=0.5
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 13090 -2030 0 1 {name=p87 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 14410 -3390 0 1 {name=M62
W=4
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 15250 -3390 0 0 {name=M63
W=4
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 15250 -2850 0 0 {name=M64
W=6
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 14410 -2850 0 1 {name=M65
W=6
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 19510 -2190 0 1 {name=M66
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 17800 -2890 0 0 {name=M68
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 17820 -2190 0 0 {name=M69
W=14
L=0.6
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 19530 -2890 0 1 {name=M67
W=12
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 18450 -2660 0 1 {name=p11 sig_type=std_logic lab=cap_res_X}
C {lab_pin.sym} 18880 -2660 0 0 {name=p28 sig_type=std_logic lab=cap_res_Y}
C {sky130_fd_pr/res_high_po_1p41.sym} 18450 -2780 0 1 {name=R1
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_1p41.sym} 18880 -2780 0 0 {name=R2
L=1.41
model=res_high_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 13050 -1310 0 1 {name=M20
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 12310 -1310 0 0 {name=M42
W=0.5
L=0.15
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 18470 -2780 1 1 {name=p52 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 18860 -2780 3 0 {name=p53 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/nfet_01v8.sym} 7680 -2410 0 0 {name=M44
W=3.0
L=0.15
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {ipin.sym} 1230 -960 0 0 {name=p60 lab=Vb2}
C {ipin.sym} 3280 -960 0 0 {name=p61 lab=Vb3}
C {ipin.sym} 6230 -2340 0 0 {name=p62 lab=V_tail_gate}
C {ipin.sym} 8340 -2980 0 0 {name=p64 lab=Vb1}
C {ipin.sym} 11380 -2070 0 0 {name=p67 lab=V_err_gate}
C {ipin.sym} 13940 -3340 0 0 {name=p70 lab=V_CMFB_S1}
C {ipin.sym} 15730 -3340 0 1 {name=p41 lab=V_CMFB_S3}
C {ipin.sym} 13940 -2900 0 0 {name=p56 lab=V_CMFB_S2}
C {ipin.sym} 15730 -2900 0 1 {name=p71 lab=V_CMFB_S4}
C {lab_wire.sym} 9130 -2230 2 0 {name=p14 sig_type=std_logic lab=GNDA}
C {lab_wire.sym} 7700 -2230 2 1 {name=p44 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/pfet_01v8.sym} 9150 -3190 0 1 {name=M45
W=7.0
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -1550 0 1 {name=M50
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -2770 0 1 {name=M54
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3400 -2770 0 1 {name=p58 sig_type=std_logic lab=Vb3}
C {lab_pin.sym} 3480 -1550 0 1 {name=p72 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 3280 -1690 0 0 {name=p73 sig_type=std_logic lab=Vb2_Vb3}
C {sky130_fd_pr/pfet_01v8.sym} 3740 -2770 0 1 {name=M55
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3740 -1550 0 1 {name=M56
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1250 -1550 0 1 {name=M94
W=3.5
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1250 -2770 0 1 {name=M95
W=1.8
L=0.2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1430 -1550 0 1 {name=p84 sig_type=std_logic lab=Vb2}
C {lab_pin.sym} 1230 -1690 0 0 {name=p85 sig_type=std_logic lab=Vb2_2}
C {sky130_fd_pr/pfet_01v8.sym} 1690 -2770 0 1 {name=M96
W=1.8
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1690 -1550 0 1 {name=M97
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 2310 -3740 0 1 {name=p74 sig_type=std_logic lab=VDDA}
C {sky130_fd_pr/pfet_01v8.sym} 2820 -3350 0 0 {name=M1
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2820 -2130 0 0 {name=M2
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 770 -3350 0 0 {name=M3
W=1.8
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 770 -2130 0 0 {name=M4
W=3.5
L=0.2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
