v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 160 -1120 1210 -890 {flags=graph
y1=-0.15
y2=2.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.0336524e-08
x2=1.2567333e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=3





color=6
node=ck1}
B 2 160 -620 1210 -390 {flags=graph
y1=-0.25748131
y2=1.9025187
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.0336524e-08
x2=1.2567333e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=3











color=6
node=vin}
B 2 160 -370 1210 -140 {flags=graph
y1=-0.34
y2=2.2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.0336524e-08
x2=1.2567333e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=3









color=5
node=vout}
B 2 160 -870 1210 -640 {flags=graph
y1=-0.15
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=1.0336524e-08
x2=1.2567333e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=3





color=18
node=ck1_b}
T {Complementary CLK Generating Circuit} 1760 -1910 0 0 0.8 0.8 {}
T {complementary_switch_FF} 3470 -1890 0 0 0.8 0.8 {}
N 570 -1250 570 -1220 {
lab=CK}
N 4170 -1730 4170 -1690 {
lab=VDD}
N 4170 -1660 4210 -1660 {
lab=VDD}
N 4210 -1710 4210 -1660 {
lab=VDD}
N 4170 -1710 4210 -1710 {
lab=VDD}
N 4170 -1150 4210 -1150 {
lab=GND}
N 4170 -1170 4170 -1120 {
lab=GND}
N 4170 -1200 4210 -1200 {
lab=GND}
N 3780 -1730 3780 -1690 {
lab=VDD}
N 3780 -1660 3820 -1660 {
lab=VDD}
N 3820 -1710 3820 -1660 {
lab=VDD}
N 3780 -1710 3820 -1710 {
lab=VDD}
N 3780 -1420 3820 -1420 {
lab=GND}
N 3820 -1420 3820 -1150 {
lab=GND}
N 3780 -1150 3820 -1150 {
lab=GND}
N 3780 -1170 3780 -1120 {
lab=GND}
N 3780 -1200 3820 -1200 {
lab=GND}
N 3320 -1730 3320 -1690 {
lab=VDD}
N 3320 -1660 3360 -1660 {
lab=VDD}
N 3360 -1710 3360 -1660 {
lab=VDD}
N 3320 -1710 3360 -1710 {
lab=VDD}
N 3320 -1420 3360 -1420 {
lab=VDD}
N 3320 -1150 3360 -1150 {
lab=GND}
N 3320 -1170 3320 -1120 {
lab=GND}
N 3320 -1200 3360 -1200 {
lab=GND}
N 3360 -1660 3360 -1420 {
lab=VDD}
N 4030 -1660 4130 -1660 {
lab=#net1}
N 4030 -1200 4130 -1200 {
lab=#net2}
N 3780 -1600 4030 -1600 {
lab=#net1}
N 3170 -1660 3280 -1660 {
lab=VIN}
N 3170 -1660 3170 -1290 {
lab=VIN}
N 3240 -1420 3280 -1420 {
lab=CK1}
N 3360 -1200 3360 -1150 {
lab=GND}
N 4030 -1260 4030 -1200 {
lab=#net2}
N 3780 -1260 4030 -1260 {
lab=#net2}
N 3590 -1200 3740 -1200 {
lab=#net3}
N 3590 -1260 3590 -1200 {
lab=#net3}
N 3320 -1260 3590 -1260 {
lab=#net3}
N 3590 -1660 3740 -1660 {
lab=#net4}
N 3590 -1660 3590 -1600 {
lab=#net4}
N 3320 -1600 3590 -1600 {
lab=#net4}
N 4030 -1660 4030 -1600 {
lab=#net1}
N 4210 -1200 4210 -1150 {
lab=GND}
N 3970 -1490 3970 -1450 {
lab=#net1}
N 3780 -1490 3970 -1490 {
lab=#net1}
N 3970 -1390 3970 -1370 {
lab=#net2}
N 3780 -1370 3970 -1370 {
lab=#net2}
N 3940 -1420 3970 -1420 {
lab=VDD}
N 3940 -1660 3940 -1420 {
lab=VDD}
N 3820 -1660 3940 -1660 {
lab=VDD}
N 3510 -1490 3510 -1450 {
lab=#net4}
N 3320 -1490 3510 -1490 {
lab=#net4}
N 3510 -1390 3510 -1370 {
lab=#net3}
N 3480 -1420 3510 -1420 {
lab=GND}
N 3320 -1370 3510 -1370 {
lab=#net3}
N 3480 -1420 3480 -1200 {
lab=GND}
N 3360 -1200 3480 -1200 {
lab=GND}
N 3320 -1730 4170 -1730 {
lab=VDD}
N 3780 -1760 3780 -1730 {
lab=VDD}
N 3320 -1120 4170 -1120 {
lab=GND}
N 3780 -1120 3780 -1090 {
lab=GND}
N 3550 -1420 3590 -1420 {
lab=CK1_b}
N 4010 -1420 4050 -1420 {
lab=CK1_b}
N 3700 -1420 3740 -1420 {
lab=CK1}
N 3100 -1510 3170 -1510 {
lab=VIN}
N 3170 -1200 3280 -1200 {
lab=VIN}
N 3170 -1290 3170 -1200 {
lab=VIN}
N 4170 -1500 4260 -1500 {
lab=VOUT}
N 3320 -1630 3320 -1450 {
lab=#net4}
N 3320 -1390 3320 -1230 {
lab=#net3}
N 3780 -1630 3780 -1450 {
lab=#net1}
N 3780 -1390 3780 -1230 {
lab=#net2}
N 4170 -1630 4170 -1230 {
lab=VOUT}
N 910 -1250 910 -1220 {
lab=VIN}
N 2140 -1720 2140 -1520 {
lab=CK}
N 2200 -1720 2200 -1520 {
lab=CK1}
N 2170 -1240 2170 -1220 {
lab=#net5}
N 2100 -1270 2130 -1270 {
lab=CK}
N 2100 -1270 2100 -1190 {
lab=CK}
N 2100 -1190 2130 -1190 {
lab=CK}
N 2170 -1160 2170 -1140 {
lab=GND}
N 2170 -1190 2190 -1190 {
lab=GND}
N 2190 -1190 2190 -1150 {
lab=GND}
N 2170 -1150 2190 -1150 {
lab=GND}
N 2170 -1320 2170 -1300 {
lab=VDD}
N 2170 -1310 2190 -1310 {
lab=VDD}
N 2190 -1310 2190 -1270 {
lab=VDD}
N 2170 -1270 2190 -1270 {
lab=VDD}
N 1860 -1440 1940 -1440 {
lab=CK}
N 2170 -1800 2170 -1760 {
lab=VDD}
N 2170 -1480 2170 -1430 {
lab=GND}
N 2170 -1720 2170 -1690 {
lab=GND}
N 2170 -1690 2230 -1690 {
lab=GND}
N 2230 -1690 2230 -1460 {
lab=GND}
N 2170 -1460 2230 -1460 {
lab=GND}
N 2170 -1540 2170 -1520 {
lab=VDD}
N 2110 -1540 2170 -1540 {
lab=VDD}
N 2110 -1770 2110 -1540 {
lab=VDD}
N 2110 -1770 2170 -1770 {
lab=VDD}
N 1940 -1620 1940 -1230 {
lab=CK}
N 2170 -1230 2400 -1230 {
lab=#net5}
N 2200 -1620 2400 -1620 {
lab=CK1}
N 1940 -1230 2100 -1230 {lab=CK}
N 1940 -1620 2140 -1620 {lab=CK}
C {devices/vsource.sym} 480 -1190 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/gnd.sym} 480 -1160 0 0 {name=l1 lab=GND}
C {devices/code.sym} 320 -1250 0 0 {name=Testbench only_toplevel=false value="

.option method=gear
.option wnflag=1

.control

  save all
  tran 2p 20n
  remzerovec
  write tb_FF_comp_sw.raw
  * set appendwrite

.endc

"}
C {sky130_fd_pr/corner.sym} 190 -1250 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/vdd.sym} 480 -1220 0 0 {name=l6 lab=VDD}
C {devices/gnd.sym} 570 -1160 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 570 -1250 0 1 {name=p19 sig_type=std_logic lab=CK}
C {devices/vsource.sym} 570 -1190 0 0 {name=V2 value="pulse(0 1.8 0ps 8.34ps 8.34ps 200.16ps 417ps)" savecurrent=false
* "pulse(0 1.8 12.5ns 0.5ns 0.5ns 12ns 25ns)"
* "pulse(0 1.8 0ps 16.68ps 16.68ps 408.32ps 834ps)"
* "pulse(0 1.8 0ps 20ps 20ps 480ps 1000ps)"}
C {devices/gnd.sym} 3780 -1090 0 0 {name=l2 lab=GND}
C {devices/vdd.sym} 3780 -1760 0 0 {name=l3 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 4150 -1660 0 0 {name=M7
L=0.15
W=0.43
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -1420 0 0 {name=M5
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4150 -1200 0 0 {name=M8
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3760 -1660 0 0 {name=M4
L=0.15
W=0.43
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3760 -1200 0 0 {name=M6
L=0.15
W=1.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -1660 0 0 {name=M1
L=0.15
W=0.43
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3300 -1200 0 0 {name=M3
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3300 -1420 0 0 {name=M2
L=0.15
W=0.43
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3990 -1420 0 1 {name=M5_c
L=0.15
W=0.43
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3530 -1420 0 1 {name=M2_c
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 4260 -1500 0 1 {name=p17 sig_type=std_logic lab=VOUT}
C {devices/lab_pin.sym} 3240 -1420 0 0 {name=p18 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 3700 -1420 0 0 {name=p2 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 3590 -1420 0 1 {name=p20 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 4050 -1420 0 1 {name=p21 sig_type=std_logic lab=CK1_b}
C {devices/gnd.sym} 910 -1160 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 910 -1250 0 1 {name=p1 sig_type=std_logic lab=VIN}
C {devices/vsource.sym} 910 -1190 0 0 {name=V1 value="pulse(0 1.8 0ps 20ps 20ps 480ps 1000ps)" savecurrent=false

* "pulse(0 1.8 0ps 40ps 40ps 960ps 2000ps)"
* "pulse(0 1.8 12.5ns 0.5ns 0.5ns 12ns 25ns)"
* "pulse(0 1.8 0ps 16.68ps 16.68ps 408.32ps 834ps)"}
C {devices/lab_pin.sym} 3100 -1510 0 0 {name=p4 sig_type=std_logic lab=VIN}
C {sky130_fd_pr/pfet_01v8.sym} 2170 -1500 3 0 {name=M10
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2170 -1740 1 0 {name=M9
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2150 -1270 0 0 {name=M15
L=0.15
W=0.86
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2150 -1190 0 0 {name=M16
L=0.15
W=0.43
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 2400 -1230 0 1 {name=p5 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 2400 -1620 0 1 {name=p6 sig_type=std_logic lab=CK1}
C {devices/vdd.sym} 2170 -1320 0 0 {name=l9 lab=VDD}
C {devices/gnd.sym} 2170 -1140 0 0 {name=l10 lab=GND}
C {devices/vdd.sym} 2170 -1800 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 2170 -1430 0 0 {name=l20 lab=GND}
C {devices/lab_pin.sym} 1860 -1440 0 0 {name=p7 sig_type=std_logic lab=CK}
