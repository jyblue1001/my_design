v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 100 -1050 1150 -820 {flags=graph
y1=-0.047
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2




color=4
node=ck1}
B 2 100 -570 1150 -340 {flags=graph
y1=-0.2
y2=2.3
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2














color=5
node=d1}
B 2 100 -810 1150 -580 {flags=graph
y1=0
y2=0.01
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2











color=5
node=ck1_b}
B 2 100 -330 1150 -100 {flags=graph
y1=-0.21
y2=2.1
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2





















color=5
node=q1_b}
B 2 100 390 1150 620 {flags=graph
y1=-0.054
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2





















color=5
node=ck2}
B 2 100 630 1150 860 {flags=graph
y1=-0.028
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2






















color=5
node=ck2_b}
B 2 100 -90 1150 140 {flags=graph
y1=-0.089
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2






















color=5
node=q2_b}
B 2 100 150 1150 380 {flags=graph
y1=-0.089
y2=2
ypos1=0
ypos2=2
divy=5
subdivy=4
unity=1
x1=0
x2=3e-08
divx=5
subdivx=4
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0











linewidth_mult=2























color=5
node=q3_b}
N 2460 -820 2460 -780 {
lab=VDD}
N 2460 -750 2500 -750 {
lab=VDD}
N 2500 -800 2500 -750 {
lab=VDD}
N 2460 -800 2500 -800 {
lab=VDD}
N 2460 -240 2500 -240 {
lab=GND}
N 2460 -290 2500 -290 {
lab=GND}
N 2460 -720 2460 -490 {
lab=Q1_b}
N 2160 -820 2160 -780 {
lab=VDD}
N 2160 -750 2200 -750 {
lab=VDD}
N 2200 -800 2200 -750 {
lab=VDD}
N 2160 -800 2200 -800 {
lab=VDD}
N 2160 -510 2200 -510 {
lab=GND}
N 2200 -510 2200 -240 {
lab=GND}
N 2160 -240 2200 -240 {
lab=GND}
N 2160 -290 2200 -290 {
lab=GND}
N 2160 -610 2160 -540 {
lab=#net1}
N 1790 -820 1790 -780 {
lab=VDD}
N 1790 -750 1830 -750 {
lab=VDD}
N 1830 -800 1830 -750 {
lab=VDD}
N 1790 -800 1830 -800 {
lab=VDD}
N 1790 -510 1830 -510 {
lab=VDD}
N 1790 -240 1830 -240 {
lab=GND}
N 1790 -290 1830 -290 {
lab=GND}
N 1830 -750 1830 -510 {
lab=VDD}
N 2320 -750 2420 -750 {
lab=B1}
N 2320 -290 2420 -290 {
lab=B2}
N 2160 -690 2320 -690 {
lab=B1}
N 1640 -750 1750 -750 {
lab=D1}
N 1640 -750 1640 -380 {
lab=D1}
N 1710 -510 1750 -510 {
lab=CK1}
N 1830 -290 1830 -240 {
lab=GND}
N 2460 -430 2460 -320 {
lab=#net2}
N 2320 -350 2320 -290 {
lab=B2}
N 2160 -350 2320 -350 {
lab=B2}
N 1970 -290 2120 -290 {
lab=A2}
N 1970 -350 1970 -290 {
lab=A2}
N 1790 -350 1970 -350 {
lab=A2}
N 1970 -750 2120 -750 {
lab=A1}
N 1970 -750 1970 -690 {
lab=A1}
N 1790 -690 1970 -690 {
lab=A1}
N 2320 -750 2320 -690 {
lab=B1}
N 2160 -720 2160 -670 {
lab=B1}
N 2500 -290 2500 -240 {
lab=GND}
N 2260 -580 2260 -540 {
lab=#net1}
N 2160 -580 2260 -580 {
lab=#net1}
N 2260 -480 2260 -460 {
lab=#net3}
N 2160 -460 2260 -460 {
lab=#net3}
N 2230 -510 2260 -510 {
lab=VDD}
N 2230 -750 2230 -510 {
lab=VDD}
N 2200 -750 2230 -750 {
lab=VDD}
N 1890 -580 1890 -540 {
lab=#net4}
N 1790 -580 1890 -580 {
lab=#net4}
N 1890 -480 1890 -460 {
lab=#net5}
N 1860 -510 1890 -510 {
lab=GND}
N 1790 -610 1790 -540 {
lab=#net4}
N 1790 -460 1890 -460 {
lab=#net5}
N 1860 -510 1860 -290 {
lab=GND}
N 1830 -290 1860 -290 {
lab=GND}
N 1790 -820 2460 -820 {
lab=VDD}
N 2160 -850 2160 -820 {
lab=VDD}
N 1930 -510 1970 -510 {
lab=CK1_b}
N 2300 -510 2340 -510 {
lab=CK1_b}
N 2080 -510 2120 -510 {
lab=CK1}
N 1330 1090 1410 1090 {
lab=CK}
N 1410 950 1410 1230 {
lab=CK}
N 4190 -1000 4190 -780 {
lab=VDD}
N 4190 -750 4230 -750 {
lab=VDD}
N 4230 -800 4230 -750 {
lab=VDD}
N 4190 -800 4230 -800 {
lab=VDD}
N 4190 -240 4230 -240 {
lab=GND}
N 4190 -260 4190 -210 {
lab=GND}
N 4190 -290 4230 -290 {
lab=GND}
N 4190 -720 4190 -460 {
lab=Q2_b}
N 3890 -1000 3890 -780 {
lab=VDD}
N 3890 -750 3930 -750 {
lab=VDD}
N 3930 -800 3930 -750 {
lab=VDD}
N 3890 -800 3930 -800 {
lab=VDD}
N 3890 -510 3930 -510 {
lab=GND}
N 3930 -510 3930 -240 {
lab=GND}
N 3890 -240 3930 -240 {
lab=GND}
N 3890 -260 3890 -210 {
lab=GND}
N 3890 -290 3930 -290 {
lab=GND}
N 3890 -610 3890 -540 {
lab=#net6}
N 3410 -750 3450 -750 {
lab=VDD}
N 3410 -510 3450 -510 {
lab=VDD}
N 3410 -260 3410 -210 {
lab=#net7}
N 3410 -290 3480 -290 {
lab=GND}
N 3450 -750 3450 -510 {
lab=VDD}
N 4050 -750 4150 -750 {
lab=B3}
N 4050 -290 4150 -290 {
lab=B4}
N 3890 -690 4050 -690 {
lab=B3}
N 3330 -510 3370 -510 {
lab=CK1}
N 4190 -400 4190 -320 {
lab=#net8}
N 4050 -350 4050 -290 {
lab=B4}
N 3890 -350 4050 -350 {
lab=B4}
N 3680 -290 3850 -290 {
lab=A4}
N 3680 -350 3680 -290 {
lab=A4}
N 3410 -350 3680 -350 {
lab=A4}
N 3680 -750 3850 -750 {
lab=A3}
N 3680 -750 3680 -690 {
lab=A3}
N 3410 -690 3680 -690 {
lab=A3}
N 4050 -750 4050 -690 {
lab=B3}
N 3890 -720 3890 -670 {
lab=B3}
N 4230 -290 4230 -240 {
lab=GND}
N 3990 -580 3990 -540 {
lab=#net6}
N 3890 -580 3990 -580 {
lab=#net6}
N 3990 -480 3990 -460 {
lab=#net9}
N 3890 -460 3990 -460 {
lab=#net9}
N 3960 -510 3990 -510 {
lab=VDD}
N 3960 -750 3960 -510 {
lab=VDD}
N 3930 -750 3960 -750 {
lab=VDD}
N 3510 -580 3510 -540 {
lab=#net10}
N 3410 -580 3510 -580 {
lab=#net10}
N 3510 -480 3510 -460 {
lab=#net11}
N 3480 -510 3510 -510 {
lab=GND}
N 3410 -720 3410 -670 {
lab=A3}
N 3410 -610 3410 -540 {
lab=#net10}
N 3410 -460 3510 -460 {
lab=#net11}
N 3480 -510 3480 -290 {
lab=GND}
N 3410 -1000 4190 -1000 {
lab=VDD}
N 3890 -1030 3890 -1000 {
lab=VDD}
N 3890 -210 3890 -180 {
lab=GND}
N 3550 -510 3590 -510 {
lab=CK1_b}
N 4030 -510 4070 -510 {
lab=CK1_b}
N 3810 -510 3850 -510 {
lab=CK1}
N 2160 -370 2160 -320 {
lab=B2}
N 2160 -480 2160 -430 {
lab=#net3}
N 1790 -480 1790 -430 {
lab=#net5}
N 1790 -370 1790 -320 {
lab=A2}
N 3890 -370 3890 -320 {
lab=B4}
N 3890 -480 3890 -430 {
lab=#net9}
N 3410 -480 3410 -430 {
lab=#net11}
N 3410 -370 3410 -320 {
lab=A4}
N 1640 -290 1750 -290 {
lab=D1}
N 1640 -380 1640 -290 {
lab=D1}
N 4190 -530 4350 -530 {
lab=Q2_b}
N 660 -1230 660 -1200 {
lab=CK}
N 1390 -10 1410 -10 {
lab=D1}
N 1360 30 1360 60 {
lab=Q2_b}
N 1360 60 1440 60 {
lab=Q2_b}
N 1440 30 1440 60 {
lab=Q2_b}
N 1470 -10 1490 -10 {
lab=GND}
N 1440 -30 1440 -10 {
lab=GND}
N 1440 -30 1480 -30 {
lab=GND}
N 1480 -30 1480 -10 {
lab=GND}
N 1310 -10 1330 -10 {
lab=VDD}
N 1320 -30 1320 -10 {
lab=VDD}
N 1320 -30 1360 -30 {
lab=VDD}
N 1360 -30 1360 -10 {
lab=VDD}
N 4350 -530 4350 150 {
lab=Q2_b}
N 1400 150 4350 150 {
lab=Q2_b}
N 1400 -600 1640 -600 {
lab=D1}
N 3050 -1000 3410 -1000 {
lab=VDD}
N 3050 -1000 3050 -780 {
lab=VDD}
N 3050 -750 3090 -750 {
lab=VDD}
N 3090 -1000 3090 -750 {
lab=VDD}
N 3890 -210 4190 -210 {
lab=GND}
N 3410 -150 3410 -110 {
lab=GND}
N 3410 -180 3480 -180 {
lab=GND}
N 3410 -130 3480 -130 {
lab=GND}
N 3050 -720 3050 -690 {
lab=A3}
N 3050 -690 3410 -690 {
lab=A3}
N 3410 -520 3410 -510 {
lab=VDD}
N 1400 60 1400 150 {
lab=Q2_b}
N 1400 -600 1400 -10 {
lab=D1}
N 3410 -1000 3410 -930 {
lab=VDD}
N 3410 -900 3450 -900 {
lab=VDD}
N 2800 -150 2800 -130 {
lab=GND}
N 2800 -240 2800 -210 {
lab=#net7}
N 3480 -290 3480 -180 {
lab=GND}
N 3480 -180 3480 -130 {
lab=GND}
N 3450 -1000 3450 -750 {
lab=VDD}
N 3410 -870 3410 -780 {
lab=#net12}
N 2800 -130 3410 -130 {
lab=GND}
N 2800 -240 3410 -240 {
lab=#net7}
N 2710 -900 3370 -900 {
lab=Q1_b}
N 2710 -900 2710 -180 {
lab=Q1_b}
N 2710 -180 2760 -180 {
lab=Q1_b}
N 2460 -540 2710 -540 {
lab=Q1_b}
N 3210 -290 3370 -290 {
lab=Q2_b}
N 2930 -180 3370 -180 {
lab=Q3_b}
N 2930 -750 2930 -180 {
lab=Q3_b}
N 2930 -750 3010 -750 {
lab=Q3_b}
N 5520 -840 5520 -800 {
lab=VDD}
N 5520 -770 5560 -770 {
lab=VDD}
N 5560 -820 5560 -770 {
lab=VDD}
N 5520 -820 5560 -820 {
lab=VDD}
N 5520 -260 5560 -260 {
lab=GND}
N 5520 -280 5520 -230 {
lab=GND}
N 5520 -310 5560 -310 {
lab=GND}
N 5520 -740 5520 -510 {
lab=Q3_b}
N 5220 -840 5220 -800 {
lab=VDD}
N 5220 -770 5260 -770 {
lab=VDD}
N 5260 -820 5260 -770 {
lab=VDD}
N 5220 -820 5260 -820 {
lab=VDD}
N 5220 -530 5260 -530 {
lab=GND}
N 5260 -530 5260 -260 {
lab=GND}
N 5220 -260 5260 -260 {
lab=GND}
N 5220 -280 5220 -230 {
lab=GND}
N 5220 -310 5260 -310 {
lab=GND}
N 5220 -630 5220 -560 {
lab=#net13}
N 4850 -840 4850 -800 {
lab=VDD}
N 4850 -770 4890 -770 {
lab=VDD}
N 4890 -820 4890 -770 {
lab=VDD}
N 4850 -820 4890 -820 {
lab=VDD}
N 4850 -530 4890 -530 {
lab=VDD}
N 4850 -260 4890 -260 {
lab=GND}
N 4850 -280 4850 -230 {
lab=GND}
N 4850 -310 4890 -310 {
lab=GND}
N 4890 -770 4890 -530 {
lab=VDD}
N 5380 -770 5480 -770 {
lab=B6}
N 5380 -310 5480 -310 {
lab=B6}
N 5220 -710 5380 -710 {
lab=B6}
N 4700 -770 4810 -770 {
lab=Q3_b}
N 4700 -770 4700 -400 {
lab=Q3_b}
N 4770 -530 4810 -530 {
lab=CK2}
N 4890 -310 4890 -260 {
lab=GND}
N 5520 -450 5520 -340 {
lab=#net14}
N 5380 -370 5380 -310 {
lab=B6}
N 5220 -370 5380 -370 {
lab=B6}
N 5030 -310 5180 -310 {
lab=A6}
N 5030 -370 5030 -310 {
lab=A6}
N 4850 -370 5030 -370 {
lab=A6}
N 5030 -770 5180 -770 {
lab=A5}
N 5030 -770 5030 -710 {
lab=A5}
N 4850 -710 5030 -710 {
lab=A5}
N 5380 -770 5380 -710 {
lab=B6}
N 5220 -740 5220 -690 {
lab=B6}
N 5560 -310 5560 -260 {
lab=GND}
N 5320 -600 5320 -560 {
lab=#net13}
N 5220 -600 5320 -600 {
lab=#net13}
N 5320 -500 5320 -480 {
lab=#net15}
N 5220 -480 5320 -480 {
lab=#net15}
N 5290 -530 5320 -530 {
lab=VDD}
N 5290 -770 5290 -530 {
lab=VDD}
N 5260 -770 5290 -770 {
lab=VDD}
N 4950 -600 4950 -560 {
lab=#net16}
N 4850 -600 4950 -600 {
lab=#net16}
N 4950 -500 4950 -480 {
lab=#net17}
N 4920 -530 4950 -530 {
lab=GND}
N 4850 -740 4850 -690 {
lab=A5}
N 4850 -630 4850 -560 {
lab=#net16}
N 4850 -480 4950 -480 {
lab=#net17}
N 4920 -530 4920 -310 {
lab=GND}
N 4890 -310 4920 -310 {
lab=GND}
N 4850 -840 5520 -840 {
lab=VDD}
N 5220 -870 5220 -840 {
lab=VDD}
N 4850 -230 5520 -230 {
lab=GND}
N 5220 -230 5220 -200 {
lab=GND}
N 4990 -530 5030 -530 {
lab=CK2_b}
N 5360 -530 5400 -530 {
lab=CK2_b}
N 5140 -530 5180 -530 {
lab=CK2}
N 5220 -390 5220 -340 {
lab=B6}
N 5220 -500 5220 -450 {
lab=#net15}
N 4850 -500 4850 -450 {
lab=#net17}
N 4850 -390 4850 -340 {
lab=A6}
N 4700 -310 4810 -310 {
lab=Q3_b}
N 4700 -400 4700 -310 {
lab=Q3_b}
N 4570 -700 4700 -700 {
lab=Q3_b}
N 4570 -1010 4570 -700 {
lab=Q3_b}
N 4570 -1010 5700 -1010 {
lab=Q3_b}
N 5700 -1010 5700 -640 {
lab=Q3_b}
N 5520 -640 5700 -640 {
lab=Q3_b}
N 1480 300 1480 430 {
lab=Q2_b}
N 1540 300 1540 430 {
lab=#net18}
N 1535 640 1535 660 {
lab=#net19}
N 1465 610 1495 610 {
lab=Q2_b}
N 1465 610 1465 690 {
lab=Q2_b}
N 1465 690 1495 690 {
lab=Q2_b}
N 1535 720 1535 740 {
lab=GND}
N 1535 690 1555 690 {
lab=GND}
N 1555 690 1555 730 {
lab=GND}
N 1535 730 1555 730 {
lab=GND}
N 1535 560 1535 580 {
lab=VDD}
N 1535 570 1555 570 {
lab=VDD}
N 1555 570 1555 610 {
lab=VDD}
N 1535 610 1555 610 {
lab=VDD}
N 1330 510 1410 510 {
lab=Q2_b}
N 1410 650 1465 650 {
lab=Q2_b}
N 1410 370 1410 650 {
lab=Q2_b}
N 2930 -180 2930 350 {
lab=Q3_b}
N 2930 350 5700 350 {
lab=Q3_b}
N 5700 -640 5700 350 {
lab=Q3_b}
N 3210 -750 3370 -750 {
lab=Q2_b}
N 3210 -750 3210 -290 {
lab=Q2_b}
N 3210 -290 3210 150 {
lab=Q2_b}
N 2800 -180 2840 -180 {
lab=GND}
N 2840 -180 2840 -130 {
lab=GND}
N 1535 650 1710 650 {
lab=#net19}
N 1410 370 1480 370 {
lab=Q2_b}
N 2460 -260 2460 -210 {
lab=GND}
N 1790 -260 1790 -210 {
lab=GND}
N 1410 950 1480 950 {
lab=CK}
N 1780 360 1780 380 {
lab=CK2_b}
N 1710 330 1740 330 {
lab=#net18}
N 1710 330 1710 410 {
lab=#net18}
N 1710 410 1740 410 {
lab=#net18}
N 1780 440 1780 460 {
lab=GND}
N 1780 410 1800 410 {
lab=GND}
N 1800 410 1800 450 {
lab=GND}
N 1780 450 1800 450 {
lab=GND}
N 1780 280 1780 300 {
lab=VDD}
N 1780 290 1800 290 {
lab=VDD}
N 1800 290 1800 330 {
lab=VDD}
N 1780 330 1800 330 {
lab=VDD}
N 1780 640 1780 660 {
lab=CK2}
N 1710 610 1740 610 {
lab=#net19}
N 1710 610 1710 690 {
lab=#net19}
N 1710 690 1740 690 {
lab=#net19}
N 1780 720 1780 740 {
lab=GND}
N 1780 690 1800 690 {
lab=GND}
N 1800 690 1800 730 {
lab=GND}
N 1780 730 1800 730 {
lab=GND}
N 1780 560 1780 580 {
lab=VDD}
N 1780 570 1800 570 {
lab=VDD}
N 1800 570 1800 610 {
lab=VDD}
N 1780 610 1800 610 {
lab=VDD}
N 1780 370 1940 370 {
lab=CK2_b}
N 1540 370 1710 370 {
lab=#net18}
N 1780 650 1940 650 {
lab=CK2}
N 1790 -720 1790 -670 {
lab=A1}
N 1790 -210 2460 -210 {
lab=GND}
N 2160 -260 2160 -210 {
lab=GND}
N 2160 -210 2160 -170 {
lab=GND}
N 1480 880 1480 1010 {
lab=CK}
N 1540 880 1540 1010 {
lab=#net20}
N 1530 1220 1530 1240 {
lab=#net21}
N 1460 1190 1490 1190 {
lab=CK}
N 1460 1190 1460 1270 {
lab=CK}
N 1460 1270 1490 1270 {
lab=CK}
N 1530 1300 1530 1320 {
lab=GND}
N 1530 1270 1550 1270 {
lab=GND}
N 1550 1270 1550 1310 {
lab=GND}
N 1530 1310 1550 1310 {
lab=GND}
N 1530 1140 1530 1160 {
lab=VDD}
N 1530 1150 1550 1150 {
lab=VDD}
N 1550 1150 1550 1190 {
lab=VDD}
N 1530 1190 1550 1190 {
lab=VDD}
N 1530 1230 1705 1230 {
lab=#net21}
N 1780 940 1780 960 {
lab=CK1_b}
N 1710 910 1740 910 {
lab=#net20}
N 1710 910 1710 990 {
lab=#net20}
N 1710 990 1740 990 {
lab=#net20}
N 1780 1020 1780 1040 {
lab=GND}
N 1780 990 1800 990 {
lab=GND}
N 1800 990 1800 1030 {
lab=GND}
N 1780 1030 1800 1030 {
lab=GND}
N 1780 860 1780 880 {
lab=VDD}
N 1780 870 1800 870 {
lab=VDD}
N 1800 870 1800 910 {
lab=VDD}
N 1780 910 1800 910 {
lab=VDD}
N 1775 1220 1775 1240 {
lab=#net22}
N 1705 1190 1735 1190 {
lab=#net21}
N 1705 1190 1705 1270 {
lab=#net21}
N 1705 1270 1735 1270 {
lab=#net21}
N 1775 1300 1775 1320 {
lab=GND}
N 1775 1270 1795 1270 {
lab=GND}
N 1795 1270 1795 1310 {
lab=GND}
N 1775 1310 1795 1310 {
lab=GND}
N 1775 1140 1775 1160 {
lab=VDD}
N 1775 1150 1795 1150 {
lab=VDD}
N 1795 1150 1795 1190 {
lab=VDD}
N 1775 1190 1795 1190 {
lab=VDD}
N 1540 950 1710 950 {
lab=#net20}
N 1410 1230 1460 1230 {
lab=CK}
N 1780 950 1970 950 {
lab=CK1_b}
N 1775 1230 1965 1230 {
lab=#net22}
C {devices/vsource.sym} 530 -1170 0 0 {name=VDD value=1.8 savecurrent=false}
C {devices/gnd.sym} 530 -1140 0 0 {name=l1 lab=GND}
C {devices/code.sym} 320 -1240 0 0 {name=Stimuli only_toplevel=false value="

.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.option method=gear
.option wnflag=1
.option savecurrents

.save
+@m.xm1.msky130_fd_pr__pfet_01v8[gm]
+@m.xm2.msky130_fd_pr__nfet_01v8[gm]
+@m.xm3.msky130_fd_pr__pfet_01v8[gm]
+@m.xm4.msky130_fd_pr__nfet_01v8[gm]
+@m.xm4_c.msky130_fd_pr__pfet_01v8[gm]
+@m.xm5.msky130_fd_pr__nfet_01v8[gm]
+@m.xm6.msky130_fd_pr__pfet_01v8[gm]
+@m.xm7.msky130_fd_pr__pfet_01v8[gm]
+@m.xm7_c.msky130_fd_pr__nfet_01v8[gm]
+@m.xm8.msky130_fd_pr__nfet_01v8[gm]

*.ic v(d)=0
*.ic v(q)=0
*.ic v(q1)=0

.control

  save v(d1) v(q1_b) v(q2_b) v(q3_b) v(a1) v(a2) v(a3) v(a4) v(a5) v(a6) v(b1) v(b2) v(b3) v(b4) v(b5) v(b6) v(ck) v(ck1) v(ck1_b) v(ck2) v(ck2_b)
  * save all
  * tran 0.1n 1u
  tran 1p 30n

  remzerovec
  write tb_TSPC_FF_comp_sw_divide3_5.raw
  * set appendwrite

.endc

"}
C {sky130_fd_pr/corner.sym} 150 -1230 0 0 {name=CORNER only_toplevel=false corner=tt}
C {devices/vdd.sym} 530 -1200 0 0 {name=l6 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 2440 -750 0 0 {name=M1
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2140 -510 0 0 {name=M4
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 2460 -460 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 2440 -290 0 0 {name=M2
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2140 -750 0 0 {name=M3
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2140 -290 0 0 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 2160 -640 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -750 0 0 {name=M6
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1770 -290 0 0 {name=M8
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 1790 -640 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 1770 -510 0 0 {name=M7
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1970 -690 0 1 {name=p7 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 1970 -350 0 1 {name=p1 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 2320 -690 0 1 {name=p2 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 2320 -350 0 1 {name=p10 sig_type=std_logic lab=B2}
C {sky130_fd_pr/pfet_01v8.sym} 2280 -510 0 1 {name=M4_c
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1910 -510 0 1 {name=M7_c
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 2160 -850 0 0 {name=l2 lab=VDD}
C {devices/gnd.sym} 2160 -180 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 1710 -510 0 0 {name=p3 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 2080 -510 0 0 {name=p4 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 1970 -510 0 1 {name=p6 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 2340 -510 0 1 {name=p12 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 1965 950 0 1 {name=p13 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 1330 1090 0 0 {name=p14 sig_type=std_logic lab=CK}
C {devices/lab_pin.sym} 1965 1230 0 1 {name=p15 sig_type=std_logic lab=CK1}
C {sky130_fd_pr/pfet_01v8.sym} 4170 -750 0 0 {name=M15
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3870 -510 0 0 {name=M16
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 4190 -430 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 4170 -290 0 0 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3870 -750 0 0 {name=M18
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3870 -290 0 0 {name=M19
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 3890 -640 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 3390 -750 0 0 {name=M20
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3390 -290 0 0 {name=M21
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 3410 -640 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 3390 -510 0 0 {name=M22
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 3680 -690 0 1 {name=p11 sig_type=std_logic lab=A3}
C {devices/lab_pin.sym} 3680 -350 0 1 {name=p16 sig_type=std_logic lab=A4}
C {devices/lab_pin.sym} 4050 -690 0 1 {name=p17 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 4050 -350 0 1 {name=p18 sig_type=std_logic lab=B4}
C {sky130_fd_pr/pfet_01v8.sym} 4010 -510 0 1 {name=M23
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3530 -510 0 1 {name=M24
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 3890 -1030 0 0 {name=l14 lab=VDD}
C {devices/lab_pin.sym} 3330 -510 0 0 {name=p20 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 3810 -510 0 0 {name=p21 sig_type=std_logic lab=CK1}
C {devices/lab_pin.sym} 3590 -510 0 1 {name=p22 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 4070 -510 0 1 {name=p23 sig_type=std_logic lab=CK1_b}
C {devices/lab_pin.sym} 4350 -530 0 1 {name=p24 sig_type=std_logic lab=Q2_b}
C {devices/ammeter.sym} 2160 -400 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 1790 -400 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 3890 -400 0 0 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 3410 -400 0 0 {name=Vmeas9 savecurrent=true spice_ignore=0}
C {devices/gnd.sym} 3890 -180 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} 660 -1140 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 660 -1230 0 1 {name=p19 sig_type=std_logic lab=CK}
C {devices/vsource.sym} 660 -1170 0 0 {name=V2 value="pulse(0 1.8 0ps 8.34ps 8.34ps 200.16ps 417ps)" savecurrent=false
* "pulse(0 1.8 12.5ns 0.5ns 0.5ns 12ns 25ns)"
* "pulse(0 1.8 0ps 16.68ps 16.68ps 408.32ps 834ps)"
* "pulse(0 1.8 0ps 20ps 20ps 480ps 1000ps)"}
C {devices/lab_pin.sym} 2540 -540 0 1 {name=p8 sig_type=std_logic lab=Q1_b}
C {sky130_fd_pr/pfet_01v8.sym} 1360 10 3 0 {name=M31
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 10 3 0 {name=M32
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1490 -10 3 0 {name=l21 lab=GND}
C {devices/vdd.sym} 1310 -10 3 0 {name=l22 lab=VDD}
C {devices/lab_pin.sym} 1400 -480 0 0 {name=p25 sig_type=std_logic lab=D1}
C {sky130_fd_pr/pfet_01v8.sym} 3030 -750 0 0 {name=M11
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3390 -180 0 0 {name=M14
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3410 -110 0 0 {name=l7 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 3390 -900 0 0 {name=M25
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2780 -180 0 0 {name=M26
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5500 -770 0 0 {name=M27
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5200 -530 0 0 {name=M28
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 5520 -480 0 0 {name=Vmeas10 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/nfet_01v8.sym} 5500 -310 0 0 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5200 -770 0 0 {name=M30
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5200 -310 0 0 {name=M33
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 5220 -660 0 0 {name=Vmeas11 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 4830 -770 0 0 {name=M34
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4830 -310 0 0 {name=M35
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ammeter.sym} 4850 -660 0 0 {name=Vmeas12 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 4830 -530 0 0 {name=M36
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 5030 -710 0 1 {name=p5 sig_type=std_logic lab=A5}
C {devices/lab_pin.sym} 5030 -370 0 1 {name=p9 sig_type=std_logic lab=A6}
C {devices/lab_pin.sym} 5380 -710 0 1 {name=p27 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 5380 -370 0 1 {name=p28 sig_type=std_logic lab=B6}
C {sky130_fd_pr/pfet_01v8.sym} 5340 -530 0 1 {name=M37
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4970 -530 0 1 {name=M38
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 5220 -870 0 0 {name=l10 lab=VDD}
C {devices/gnd.sym} 5220 -200 0 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 4770 -530 0 0 {name=p29 sig_type=std_logic lab=CK2}
C {devices/lab_pin.sym} 5140 -530 0 0 {name=p30 sig_type=std_logic lab=CK2}
C {devices/lab_pin.sym} 5030 -530 0 1 {name=p31 sig_type=std_logic lab=CK2_b}
C {devices/lab_pin.sym} 5400 -530 0 1 {name=p32 sig_type=std_logic lab=CK2_b}
C {devices/ammeter.sym} 5220 -420 0 0 {name=Vmeas13 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 4850 -420 0 0 {name=Vmeas14 savecurrent=true spice_ignore=0}
C {sky130_fd_pr/pfet_01v8.sym} 1510 450 3 0 {name=M39
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1510 280 1 0 {name=M40
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1510 260 0 0 {name=l18 lab=VDD}
C {devices/gnd.sym} 1510 470 0 0 {name=l19 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1515 610 0 0 {name=M41
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1515 690 0 0 {name=M42
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1535 740 0 0 {name=l20 lab=GND}
C {devices/vdd.sym} 1535 560 0 0 {name=l23 lab=VDD}
C {devices/lab_pin.sym} 1940 370 0 1 {name=p33 sig_type=std_logic lab=CK2_b}
C {devices/vdd.sym} 1510 430 0 0 {name=l24 lab=VDD}
C {devices/gnd.sym} 1510 300 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 1940 650 0 1 {name=p35 sig_type=std_logic lab=CK2}
C {devices/lab_pin.sym} 5700 -640 0 1 {name=p36 sig_type=std_logic lab=Q3_b}
C {devices/lab_pin.sym} 1330 510 0 0 {name=p34 sig_type=std_logic lab=Q2_b}
C {devices/lab_pin.sym} 3210 -540 0 0 {name=p37 sig_type=std_logic lab=Q2_b}
C {devices/lab_pin.sym} 2930 -540 0 0 {name=p38 sig_type=std_logic lab=Q3_b}
C {sky130_fd_pr/pfet_01v8.sym} 1760 330 0 0 {name=M43
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1760 410 0 0 {name=M44
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1780 460 0 0 {name=l15 lab=GND}
C {devices/vdd.sym} 1780 280 0 0 {name=l26 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1760 610 0 0 {name=M45
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1760 690 0 0 {name=M46
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1780 740 0 0 {name=l27 lab=GND}
C {devices/vdd.sym} 1780 560 0 0 {name=l28 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1510 1030 3 0 {name=M9
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1510 860 1 0 {name=M10
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1510 840 0 0 {name=l3 lab=VDD}
C {devices/gnd.sym} 1510 1050 0 0 {name=l4 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1510 1190 0 0 {name=M12
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1510 1270 0 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1530 1320 0 0 {name=l8 lab=GND}
C {devices/vdd.sym} 1530 1140 0 0 {name=l9 lab=VDD}
C {devices/vdd.sym} 1510 1010 0 0 {name=l11 lab=VDD}
C {devices/gnd.sym} 1510 880 0 0 {name=l12 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} 1760 910 0 0 {name=M47
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1760 990 0 0 {name=M48
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1780 1040 0 0 {name=l29 lab=GND}
C {devices/vdd.sym} 1780 860 0 0 {name=l30 lab=VDD}
C {sky130_fd_pr/pfet_01v8.sym} 1755 1190 0 0 {name=M49
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1755 1270 0 0 {name=M50
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1775 1320 0 0 {name=l31 lab=GND}
C {devices/vdd.sym} 1775 1140 0 0 {name=l32 lab=VDD}
