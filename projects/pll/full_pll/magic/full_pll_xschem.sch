v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1180 -1410 1280 -1410 {
lab=UP_PFD_b}
N 1220 -940 1410 -940 {
lab=DOWN_b_b}
N 920 -1410 960 -1410 {
lab=UP_PFD}
N 920 -940 960 -940 {
lab=DOWN_PFD}
N 1410 -1030 1410 -860 {
lab=DOWN_b_b}
N 1470 -1030 1470 -860 {
lab=DOWN_b}
N 1440 -1110 1440 -1070 {
lab=VDDA}
N 1440 -870 1440 -860 {
lab=VDDA}
N 1440 -870 1480 -870 {
lab=VDDA}
N 1480 -1080 1480 -870 {
lab=VDDA}
N 1440 -1080 1480 -1080 {
lab=VDDA}
N 1440 -1030 1440 -1020 {
lab=GNDA}
N 1400 -1020 1440 -1020 {
lab=GNDA}
N 1400 -1020 1400 -810 {
lab=GNDA}
N 1400 -810 1440 -810 {
lab=GNDA}
N 1440 -820 1440 -770 {
lab=GNDA}
N 1080 -960 1080 -920 {
lab=DOWN_b_b}
N 1010 -990 1040 -990 {
lab=DOWN_PFD}
N 1010 -990 1010 -890 {
lab=DOWN_PFD}
N 1010 -890 1040 -890 {
lab=DOWN_PFD}
N 1080 -940 1220 -940 {
lab=DOWN_b_b}
N 960 -940 1010 -940 {
lab=DOWN_PFD}
N 1080 -860 1080 -820 {
lab=GNDA}
N 1080 -1060 1080 -1020 {
lab=VDDA}
N 1080 -990 1110 -990 {
lab=VDDA}
N 1110 -1040 1110 -990 {
lab=VDDA}
N 1080 -1040 1110 -1040 {
lab=VDDA}
N 1080 -890 1110 -890 {
lab=GNDA}
N 1110 -890 1110 -840 {
lab=GNDA}
N 1080 -840 1110 -840 {
lab=GNDA}
N 1080 -1430 1080 -1390 {
lab=UP_PFD_b}
N 1010 -1460 1040 -1460 {
lab=UP_PFD}
N 1010 -1460 1010 -1360 {
lab=UP_PFD}
N 1010 -1360 1040 -1360 {
lab=UP_PFD}
N 1080 -1410 1180 -1410 {
lab=UP_PFD_b}
N 960 -1410 1010 -1410 {
lab=UP_PFD}
N 1080 -1330 1080 -1290 {
lab=GNDA}
N 1080 -1530 1080 -1490 {
lab=VDDA}
N 1080 -1460 1110 -1460 {
lab=VDDA}
N 1110 -1510 1110 -1460 {
lab=VDDA}
N 1080 -1510 1110 -1510 {
lab=VDDA}
N 1080 -1360 1110 -1360 {
lab=GNDA}
N 1110 -1360 1110 -1310 {
lab=GNDA}
N 1080 -1310 1110 -1310 {
lab=GNDA}
N 1440 -1430 1440 -1390 {
lab=UP}
N 1370 -1460 1400 -1460 {
lab=UP_PFD_b}
N 1370 -1460 1370 -1360 {
lab=UP_PFD_b}
N 1370 -1360 1400 -1360 {
lab=UP_PFD_b}
N 1280 -1410 1370 -1410 {
lab=UP_PFD_b}
N 1440 -1330 1440 -1290 {
lab=GNDA}
N 1440 -1530 1440 -1490 {
lab=VDDA}
N 1440 -1460 1470 -1460 {
lab=VDDA}
N 1470 -1510 1470 -1460 {
lab=VDDA}
N 1440 -1510 1470 -1510 {
lab=VDDA}
N 1440 -1360 1470 -1360 {
lab=GNDA}
N 1470 -1360 1470 -1310 {
lab=GNDA}
N 1440 -1310 1470 -1310 {
lab=GNDA}
N 1440 -1410 2310 -1410 {
lab=UP}
N 1770 -470 1900 -470 {
lab=I_IN}
N 1730 -220 2230 -220 {
lab=GNDA}
N 1690 -470 1730 -470 {
lab=GNDA}
N 1690 -470 1690 -220 {
lab=GNDA}
N 1690 -220 1730 -220 {
lab=GNDA}
N 1940 -470 1980 -470 {
lab=GNDA}
N 1900 -1740 1940 -1740 {
lab=VDDA}
N 2230 -220 2270 -220 {
lab=GNDA}
N 1900 -2020 1900 -1740 {
lab=VDDA}
N 2870 -2020 2870 -1960 {
lab=VDDA}
N 2870 -1930 2890 -1930 {
lab=VDDA}
N 2890 -2020 2890 -1930 {
lab=VDDA}
N 3140 -2020 3140 -1740 {
lab=VDDA}
N 2270 -220 2870 -220 {
lab=GNDA}
N 2870 -410 2870 -220 {
lab=GNDA}
N 3100 -600 3140 -600 {
lab=GNDA}
N 3100 -220 3140 -220 {
lab=GNDA}
N 2130 -1740 2130 -1320 {
lab=opamp_out}
N 1810 -680 1810 -470 {
lab=I_IN}
N 1730 -680 1810 -680 {
lab=I_IN}
N 1980 -470 1980 -220 {
lab=GNDA}
N 1880 -600 2620 -600 {
lab=I_IN}
N 2650 -1630 2650 -1410 {
lab=UP_b}
N 2310 -1930 2830 -1930 {
lab=UP}
N 2310 -1930 2310 -1410 {
lab=UP}
N 2870 -1900 2870 -1740 {
lab=UP_input}
N 2680 -1740 3060 -1740 {
lab=UP_input}
N 2590 -940 2650 -940 {
lab=DOWN}
N 2650 -940 2650 -710 {
lab=DOWN}
N 2310 -940 2310 -440 {
lab=DOWN_b}
N 2310 -440 2830 -440 {
lab=DOWN_b}
N 2500 -960 2500 -920 {
lab=DOWN}
N 2430 -990 2460 -990 {
lab=DOWN_b}
N 2430 -990 2430 -890 {
lab=DOWN_b}
N 2430 -890 2460 -890 {
lab=DOWN_b}
N 2500 -860 2500 -820 {
lab=GNDA}
N 2500 -1060 2500 -1020 {
lab=VDDA}
N 2500 -990 2530 -990 {
lab=VDDA}
N 2530 -1040 2530 -990 {
lab=VDDA}
N 2500 -1040 2530 -1040 {
lab=VDDA}
N 2500 -890 2530 -890 {
lab=GNDA}
N 2530 -890 2530 -840 {
lab=GNDA}
N 2500 -840 2530 -840 {
lab=GNDA}
N 2500 -940 2590 -940 {
lab=DOWN}
N 2500 -1430 2500 -1390 {
lab=UP_b}
N 2430 -1460 2460 -1460 {
lab=UP}
N 2430 -1460 2430 -1360 {
lab=UP}
N 2430 -1360 2460 -1360 {
lab=UP}
N 2310 -1410 2430 -1410 {
lab=UP}
N 2500 -1330 2500 -1290 {
lab=GNDA}
N 2500 -1530 2500 -1490 {
lab=VDDA}
N 2500 -1460 2530 -1460 {
lab=VDDA}
N 2530 -1510 2530 -1460 {
lab=VDDA}
N 2500 -1510 2530 -1510 {
lab=VDDA}
N 2500 -1360 2530 -1360 {
lab=GNDA}
N 2530 -1360 2530 -1310 {
lab=GNDA}
N 2500 -1310 2530 -1310 {
lab=GNDA}
N 2500 -1410 2590 -1410 {
lab=UP_b}
N 2590 -1410 2650 -1410 {
lab=UP_b}
N 1730 -720 1730 -500 {
lab=I_IN}
N 1730 -780 1730 -720 {
lab=I_IN}
N 2680 -1810 2680 -1740 {
lab=UP_input}
N 2620 -1810 2620 -1670 {
lab=opamp_out}
N 2680 -1740 2680 -1670 {
lab=UP_input}
N 1980 -1740 2620 -1740 {
lab=opamp_out}
N 2870 -220 3100 -220 {
lab=GNDA}
N 2680 -670 2680 -530 {
lab=DOWN_input}
N 2620 -670 2620 -530 {
lab=I_IN}
N 2680 -600 3060 -600 {
lab=DOWN_input}
N 3140 -600 3140 -220 {
lab=GNDA}
N 1880 -600 1880 -470 {
lab=I_IN}
N 2870 -600 2870 -470 {
lab=DOWN_input}
N 2870 -440 2890 -440 {
lab=GNDA}
N 2890 -440 2890 -220 {
lab=GNDA}
N 2650 -490 2650 -440 {
lab=DOWN_b}
N 2650 -1930 2650 -1850 {
lab=UP}
N 2650 -1410 2790 -1410 {
lab=UP_b}
N 2790 -1540 2790 -1410 {
lab=UP_b}
N 2790 -1740 2790 -1600 {
lab=UP_input}
N 2790 -940 2790 -800 {
lab=DOWN}
N 2790 -740 2790 -600 {
lab=DOWN_input}
N 2650 -940 2790 -940 {
lab=DOWN}
N 3100 -1190 3180 -1190 {
lab=V_CONT}
N 1470 -940 2310 -940 {
lab=DOWN_b}
N 2310 -940 2430 -940 {
lab=DOWN_b}
N 2450 -2080 2450 -2020 {
lab=VDDA}
N 2450 -220 2450 -160 {
lab=GNDA}
N 2650 -560 2710 -560 {
lab=VDDA}
N 2650 -560 2650 -530 {
lab=VDDA}
N 2650 -670 2650 -640 {
lab=GNDA}
N 2650 -640 2710 -640 {
lab=GNDA}
N 2650 -1700 2710 -1700 {
lab=VDDA}
N 2650 -1700 2650 -1670 {
lab=VDDA}
N 2650 -1810 2650 -1780 {
lab=GNDA}
N 2650 -1780 2710 -1780 {
lab=GNDA}
N 1730 -1580 1730 -780 {lab=I_IN}
N 1940 -1710 1940 -500 {lab=x}
N 3100 -1710 3100 -1190 {lab=V_CONT}
N 3100 -1190 3100 -630 {lab=V_CONT}
N 1940 -1190 2110 -1190 {lab=x}
N 2150 -1190 3100 -1190 {lab=V_CONT}
N 1900 -1850 1940 -1850 {
lab=VDDA}
N 1940 -1820 1940 -1770 {lab=VDDA}
N 1940 -2020 1940 -1880 {lab=VDDA}
N 3100 -1820 3100 -1770 {lab=VDDA}
N 3100 -2020 3100 -1880 {lab=VDDA}
N 3060 -2020 3060 -1850 {lab=VDDA}
N 1980 -2020 1980 -1850 {lab=VDDA}
N 1940 -1800 1980 -1800 {lab=VDDA}
N 1980 -1850 1980 -1800 {lab=VDDA}
N 3100 -1850 3140 -1850 {lab=VDDA}
N 3060 -1800 3100 -1800 {lab=VDDA}
N 3060 -1850 3060 -1800 {lab=VDDA}
N 3100 -1740 3140 -1740 {lab=VDDA}
N 1730 -440 1730 -360 {
lab=GNDA}
N 1940 -440 1940 -360 {
lab=GNDA}
N 3100 -570 3100 -360 {
lab=GNDA}
N 1690 -330 1730 -330 {
lab=GNDA}
N 1940 -330 1980 -330 {
lab=GNDA}
N 1730 -300 1730 -220 {lab=GNDA}
N 1940 -300 1940 -220 {lab=GNDA}
N 1900 -330 1900 -220 {lab=GNDA}
N 1770 -330 1770 -220 {lab=GNDA}
N 1730 -390 1770 -390 {lab=GNDA}
N 1770 -390 1770 -330 {lab=GNDA}
N 1900 -390 1900 -330 {lab=GNDA}
N 1900 -390 1940 -390 {lab=GNDA}
N 3100 -300 3100 -220 {lab=GNDA}
N 3060 -330 3060 -220 {lab=GNDA}
N 3060 -400 3060 -330 {lab=GNDA}
N 3060 -400 3100 -400 {lab=GNDA}
N 3100 -330 3140 -330 {lab=GNDA}
N 1900 -2020 3140 -2020 {lab=VDDA}
N 3460 -1080 3460 -1030 {
lab=R1_C1}
N 3410 -1110 3440 -1110 {
lab=GNDA}
N 3410 -1110 3410 -940 {
lab=GNDA}
N 3410 -940 3460 -940 {
lab=GNDA}
N 3460 -980 3460 -890 {lab=GNDA}
N 3180 -1190 3730 -1190 {lab=V_CONT}
N 3290 -1190 3290 -1140 {lab=V_CONT}
N 3460 -1190 3460 -1140 {lab=V_CONT}
N 3290 -1080 3290 -990 {lab=GNDA}
N 3930 -1190 4320 -1190 {lab=V_OSC}
N 4500 -1190 4560 -1190 {lab=F_VCO}
C {devices/lab_wire.sym} 1220 -1410 0 1 {name=p15 sig_type=std_logic lab=UP_PFD_b}
C {devices/lab_wire.sym} 920 -1410 0 0 {name=p2 sig_type=std_logic lab=UP_PFD}
C {devices/lab_wire.sym} 920 -940 2 1 {name=p7 sig_type=std_logic lab=DOWN_PFD}
C {sky130_fd_pr/pfet_01v8.sym} 1440 -840 3 0 {name=M12
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1440 -1050 1 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 -990 0 0 {name=M10
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1060 -890 2 1 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 -1460 0 0 {name=M14
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1060 -1360 2 1 {name=M15
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1420 -1460 0 0 {name=M16
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1420 -1360 2 1 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 4000 -770 0 0 {name=p3 lab=VDDA}
C {devices/opin.sym} 4050 -770 0 0 {name=p11 lab=V_OSC}
C {devices/lab_pin.sym} 1080 -820 0 1 {name=p27 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 1080 -1060 0 1 {name=p28 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 1440 -770 0 1 {name=p29 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 1440 -1110 0 1 {name=p30 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 1080 -1290 0 1 {name=p31 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 1080 -1530 0 1 {name=p32 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 1440 -1290 0 1 {name=p33 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 1440 -1530 0 1 {name=p34 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 4000 -730 0 0 {name=p35 lab=GNDA}
C {devices/ipin.sym} 4000 -690 0 0 {name=p36 lab=F_REF}
C {devices/ipin.sym} 4000 -650 0 0 {name=p38 lab=I_IN}
C {sky130_fd_pr/nfet_01v8.sym} 1750 -470 0 1 {name=M22
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1920 -470 0 0 {name=M23
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1960 -1740 2 0 {name=M24
L=0.6
W=8
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1940 -1150 0 0 {name=p9 sig_type=std_logic lab=x}
C {sky130_fd_pr/pfet_01v8.sym} 2650 -1650 3 0 {name=M25
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2850 -1930 0 0 {name=M26
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3080 -1740 0 0 {name=M27
L=0.6
W=8
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 2310 -1410 2 1 {name=p19 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} 2650 -1450 0 1 {name=p39 sig_type=std_logic lab=UP_b}
C {sky130_fd_pr/nfet_01v8.sym} 2650 -690 1 0 {name=M28
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2850 -440 0 0 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 2310 -940 0 0 {name=p40 sig_type=std_logic lab=DOWN_b}
C {sky130_fd_pr/nfet_01v8.sym} 3080 -600 0 0 {name=M30
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 2890 -1740 2 0 {name=p41 sig_type=std_logic lab=UP_input}
C {devices/lab_wire.sym} 3020 -600 0 0 {name=p42 sig_type=std_logic lab=DOWN_input}
C {devices/lab_wire.sym} 2230 -1740 0 0 {name=p43 sig_type=std_logic lab=opamp_out}
C {sky130_fd_pr/pfet_01v8.sym} 2480 -990 0 0 {name=M31
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2480 -890 2 1 {name=M32
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2480 -1460 0 0 {name=M33
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2480 -1360 2 1 {name=M34
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1730 -1580 0 1 {name=p44 sig_type=std_logic lab=I_IN}
C {devices/lab_wire.sym} 2650 -940 0 1 {name=p45 sig_type=std_logic lab=DOWN}
C {sky130_fd_pr/nfet_01v8.sym} 2650 -1830 1 0 {name=M35
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2650 -510 3 0 {name=M36
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2790 -1570 0 0 {name=C1 model=cap_mim_m3_1 W=7 L=6.3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2790 -770 2 0 {name=C2 model=cap_mim_m3_1 W=3.8 L=2.6 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 2450 -2080 0 1 {name=p26 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2450 -160 0 1 {name=p18 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 2500 -1530 0 1 {name=p5 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2500 -1290 0 1 {name=p6 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 2500 -1060 0 1 {name=p8 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2500 -820 0 1 {name=p10 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 2710 -560 0 1 {name=p13 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2710 -640 0 1 {name=p14 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 2710 -1700 0 1 {name=p16 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2710 -1780 0 1 {name=p17 sig_type=std_logic lab=GNDA}
C {devices/lab_wire.sym} 1230 -940 2 0 {name=p1 sig_type=std_logic lab=DOWN_b_b}
C {devices/lab_pin.sym} 2060 -1250 0 0 {name=p4 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 2200 -1250 0 1 {name=p20 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 320 -1270 0 0 {name=p21 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 320 -1150 0 0 {name=p22 sig_type=std_logic lab=GNDA}
C {devices/lab_wire.sym} 470 -1230 0 1 {name=p23 sig_type=std_logic lab=UP_PFD}
C {devices/lab_wire.sym} 470 -1190 2 0 {name=p24 sig_type=std_logic lab=DOWN_PFD}
C {devices/lab_wire.sym} 170 -1230 0 0 {name=p25 sig_type=std_logic lab=F_REF}
C {devices/lab_wire.sym} 170 -1190 2 1 {name=p46 sig_type=std_logic lab=F_VCO}
C {/foss/designs/my_design/projects/pll/pfd/xschem_ngspice/phase_frequency_detector_5.sym} 320 -1210 0 0 {name=x2}
C {sky130_fd_pr/pfet_01v8.sym} 1960 -1850 0 1 {name=M19
L=0.6
W=4
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3080 -1850 0 0 {name=M20
L=0.6
W=4
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1920 -330 0 0 {name=M21
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1750 -330 0 1 {name=M37
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 3080 -330 0 0 {name=M38
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/foss/designs/my_design/projects/pll/charge_pump/xschem_ngspice/rail_to_rail_opamp6_3.sym} 2130 -1250 3 0 {name=x1}
C {devices/lab_pin.sym} 3460 -890 0 1 {name=p49 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3290 -1110 2 0 {name=C3 model=cap_mim_m3_1 W=13.8 L=60 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3460 -1010 2 0 {name=C4 model=cap_mim_m3_1 W=69.8 L=60 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 3460 -1110 0 0 {name=R1
L=7.52
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_pin.sym} 3290 -990 0 1 {name=p51 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 3460 -1060 0 1 {name=p52 sig_type=std_logic lab=R1_C1}
C {lab_pin.sym} 3830 -1290 0 0 {name=p47 lab=VDDA}
C {lab_pin.sym} 3830 -1090 0 0 {name=p50 lab=GNDA}
C {lab_pin.sym} 4410 -1240 0 0 {name=p54 lab=VDDA}
C {lab_pin.sym} 4410 -1140 0 0 {name=p55 lab=GNDA}
C {lab_wire.sym} 4160 -1190 2 0 {name=p56 sig_type=std_logic lab=V_OSC}
C {/foss/designs/my_design/projects/pll/vco/xschem_ngspice/current_starved_VCO12.sym} 3830 -1190 0 0 {name=x3}
C {/foss/designs/my_design/projects/pll/divider/xschem_ngspice/divide_by_120/divide_by_120_xschem.sym} 4410 -1190 0 0 {name=x4}
C {devices/lab_wire.sym} 4560 -1190 2 0 {name=p48 sig_type=std_logic lab=F_VCO}
C {lab_wire.sym} 3670 -1190 0 0 {name=p12 sig_type=std_logic lab=V_CONT}
