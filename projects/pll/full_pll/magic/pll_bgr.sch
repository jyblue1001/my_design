v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 4990 -1410 5090 -1410 {
lab=UP_PFD_b}
N 5030 -940 5220 -940 {
lab=DOWN_b_b}
N 4730 -1410 4770 -1410 {
lab=UP_PFD}
N 4730 -940 4770 -940 {
lab=DOWN_PFD}
N 5220 -1030 5220 -860 {
lab=DOWN_b_b}
N 5280 -1030 5280 -860 {
lab=DOWN_b}
N 5250 -1110 5250 -1070 {
lab=VDDA}
N 5250 -870 5250 -860 {
lab=VDDA}
N 5250 -870 5290 -870 {
lab=VDDA}
N 5290 -1080 5290 -870 {
lab=VDDA}
N 5250 -1080 5290 -1080 {
lab=VDDA}
N 5250 -1030 5250 -1020 {
lab=GNDA}
N 5210 -1020 5250 -1020 {
lab=GNDA}
N 5210 -1020 5210 -810 {
lab=GNDA}
N 5210 -810 5250 -810 {
lab=GNDA}
N 5250 -820 5250 -770 {
lab=GNDA}
N 4890 -960 4890 -920 {
lab=DOWN_b_b}
N 4820 -990 4850 -990 {
lab=DOWN_PFD}
N 4820 -990 4820 -890 {
lab=DOWN_PFD}
N 4820 -890 4850 -890 {
lab=DOWN_PFD}
N 4890 -940 5030 -940 {
lab=DOWN_b_b}
N 4770 -940 4820 -940 {
lab=DOWN_PFD}
N 4890 -860 4890 -820 {
lab=GNDA}
N 4890 -1060 4890 -1020 {
lab=VDDA}
N 4890 -990 4920 -990 {
lab=VDDA}
N 4920 -1040 4920 -990 {
lab=VDDA}
N 4890 -1040 4920 -1040 {
lab=VDDA}
N 4890 -890 4920 -890 {
lab=GNDA}
N 4920 -890 4920 -840 {
lab=GNDA}
N 4890 -840 4920 -840 {
lab=GNDA}
N 4890 -1430 4890 -1390 {
lab=UP_PFD_b}
N 4820 -1460 4850 -1460 {
lab=UP_PFD}
N 4820 -1460 4820 -1360 {
lab=UP_PFD}
N 4820 -1360 4850 -1360 {
lab=UP_PFD}
N 4890 -1410 4990 -1410 {
lab=UP_PFD_b}
N 4770 -1410 4820 -1410 {
lab=UP_PFD}
N 4890 -1330 4890 -1290 {
lab=GNDA}
N 4890 -1530 4890 -1490 {
lab=VDDA}
N 4890 -1460 4920 -1460 {
lab=VDDA}
N 4920 -1510 4920 -1460 {
lab=VDDA}
N 4890 -1510 4920 -1510 {
lab=VDDA}
N 4890 -1360 4920 -1360 {
lab=GNDA}
N 4920 -1360 4920 -1310 {
lab=GNDA}
N 4890 -1310 4920 -1310 {
lab=GNDA}
N 5250 -1430 5250 -1390 {
lab=UP}
N 5180 -1460 5210 -1460 {
lab=UP_PFD_b}
N 5180 -1460 5180 -1360 {
lab=UP_PFD_b}
N 5180 -1360 5210 -1360 {
lab=UP_PFD_b}
N 5090 -1410 5180 -1410 {
lab=UP_PFD_b}
N 5250 -1330 5250 -1290 {
lab=GNDA}
N 5250 -1530 5250 -1490 {
lab=VDDA}
N 5250 -1460 5280 -1460 {
lab=VDDA}
N 5280 -1510 5280 -1460 {
lab=VDDA}
N 5250 -1510 5280 -1510 {
lab=VDDA}
N 5250 -1360 5280 -1360 {
lab=GNDA}
N 5280 -1360 5280 -1310 {
lab=GNDA}
N 5250 -1310 5280 -1310 {
lab=GNDA}
N 5250 -1410 6120 -1410 {
lab=UP}
N 5580 -470 5710 -470 {
lab=I_IN}
N 5540 -220 6040 -220 {
lab=GNDA}
N 5500 -470 5540 -470 {
lab=GNDA}
N 5500 -470 5500 -220 {
lab=GNDA}
N 5500 -220 5540 -220 {
lab=GNDA}
N 5750 -470 5790 -470 {
lab=GNDA}
N 5710 -1740 5750 -1740 {
lab=VDDA}
N 6040 -220 6080 -220 {
lab=GNDA}
N 5710 -2020 5710 -1740 {
lab=VDDA}
N 6680 -2020 6680 -1960 {
lab=VDDA}
N 6680 -1930 6700 -1930 {
lab=VDDA}
N 6700 -2020 6700 -1930 {
lab=VDDA}
N 6950 -2020 6950 -1740 {
lab=VDDA}
N 6080 -220 6680 -220 {
lab=GNDA}
N 6680 -410 6680 -220 {
lab=GNDA}
N 6910 -600 6950 -600 {
lab=GNDA}
N 6910 -220 6950 -220 {
lab=GNDA}
N 5940 -1740 5940 -1320 {
lab=opamp_out}
N 5620 -680 5620 -470 {
lab=I_IN}
N 5540 -680 5620 -680 {
lab=I_IN}
N 5790 -470 5790 -220 {
lab=GNDA}
N 5690 -600 6430 -600 {
lab=I_IN}
N 6460 -1630 6460 -1410 {
lab=UP_b}
N 6120 -1930 6640 -1930 {
lab=UP}
N 6120 -1930 6120 -1410 {
lab=UP}
N 6680 -1900 6680 -1740 {
lab=UP_input}
N 6490 -1740 6870 -1740 {
lab=UP_input}
N 6400 -940 6460 -940 {
lab=DOWN}
N 6460 -940 6460 -710 {
lab=DOWN}
N 6120 -940 6120 -440 {
lab=DOWN_b}
N 6120 -440 6640 -440 {
lab=DOWN_b}
N 6310 -960 6310 -920 {
lab=DOWN}
N 6240 -990 6270 -990 {
lab=DOWN_b}
N 6240 -990 6240 -890 {
lab=DOWN_b}
N 6240 -890 6270 -890 {
lab=DOWN_b}
N 6310 -860 6310 -820 {
lab=GNDA}
N 6310 -1060 6310 -1020 {
lab=VDDA}
N 6310 -990 6340 -990 {
lab=VDDA}
N 6340 -1040 6340 -990 {
lab=VDDA}
N 6310 -1040 6340 -1040 {
lab=VDDA}
N 6310 -890 6340 -890 {
lab=GNDA}
N 6340 -890 6340 -840 {
lab=GNDA}
N 6310 -840 6340 -840 {
lab=GNDA}
N 6310 -940 6400 -940 {
lab=DOWN}
N 6310 -1430 6310 -1390 {
lab=UP_b}
N 6240 -1460 6270 -1460 {
lab=UP}
N 6240 -1460 6240 -1360 {
lab=UP}
N 6240 -1360 6270 -1360 {
lab=UP}
N 6120 -1410 6240 -1410 {
lab=UP}
N 6310 -1330 6310 -1290 {
lab=GNDA}
N 6310 -1530 6310 -1490 {
lab=VDDA}
N 6310 -1460 6340 -1460 {
lab=VDDA}
N 6340 -1510 6340 -1460 {
lab=VDDA}
N 6310 -1510 6340 -1510 {
lab=VDDA}
N 6310 -1360 6340 -1360 {
lab=GNDA}
N 6340 -1360 6340 -1310 {
lab=GNDA}
N 6310 -1310 6340 -1310 {
lab=GNDA}
N 6310 -1410 6400 -1410 {
lab=UP_b}
N 6400 -1410 6460 -1410 {
lab=UP_b}
N 5540 -720 5540 -500 {
lab=I_IN}
N 5540 -780 5540 -720 {
lab=I_IN}
N 6490 -1810 6490 -1740 {
lab=UP_input}
N 6430 -1810 6430 -1670 {
lab=opamp_out}
N 6490 -1740 6490 -1670 {
lab=UP_input}
N 5790 -1740 6430 -1740 {
lab=opamp_out}
N 6680 -220 6910 -220 {
lab=GNDA}
N 6490 -670 6490 -530 {
lab=DOWN_input}
N 6430 -670 6430 -530 {
lab=I_IN}
N 6490 -600 6870 -600 {
lab=DOWN_input}
N 6950 -600 6950 -220 {
lab=GNDA}
N 5690 -600 5690 -470 {
lab=I_IN}
N 6680 -600 6680 -470 {
lab=DOWN_input}
N 6680 -440 6700 -440 {
lab=GNDA}
N 6700 -440 6700 -220 {
lab=GNDA}
N 6460 -490 6460 -440 {
lab=DOWN_b}
N 6460 -1930 6460 -1850 {
lab=UP}
N 6460 -1410 6600 -1410 {
lab=UP_b}
N 6600 -1540 6600 -1410 {
lab=UP_b}
N 6600 -1740 6600 -1600 {
lab=UP_input}
N 6600 -940 6600 -800 {
lab=DOWN}
N 6600 -740 6600 -600 {
lab=DOWN_input}
N 6460 -940 6600 -940 {
lab=DOWN}
N 6910 -1190 6990 -1190 {
lab=V_CONT}
N 5280 -940 6120 -940 {
lab=DOWN_b}
N 6120 -940 6240 -940 {
lab=DOWN_b}
N 6260 -2080 6260 -2020 {
lab=VDDA}
N 6260 -220 6260 -160 {
lab=GNDA}
N 6460 -560 6520 -560 {
lab=VDDA}
N 6460 -560 6460 -530 {
lab=VDDA}
N 6460 -670 6460 -640 {
lab=GNDA}
N 6460 -640 6520 -640 {
lab=GNDA}
N 6460 -1700 6520 -1700 {
lab=VDDA}
N 6460 -1700 6460 -1670 {
lab=VDDA}
N 6460 -1810 6460 -1780 {
lab=GNDA}
N 6460 -1780 6520 -1780 {
lab=GNDA}
N 5540 -1580 5540 -780 {lab=I_IN}
N 5750 -1710 5750 -500 {lab=x}
N 6910 -1710 6910 -1190 {lab=V_CONT}
N 6910 -1190 6910 -630 {lab=V_CONT}
N 5750 -1190 5920 -1190 {lab=x}
N 5960 -1190 6910 -1190 {lab=V_CONT}
N 5710 -1850 5750 -1850 {
lab=VDDA}
N 5750 -1820 5750 -1770 {lab=VDDA}
N 5750 -2020 5750 -1880 {lab=VDDA}
N 6910 -1820 6910 -1770 {lab=VDDA}
N 6910 -2020 6910 -1880 {lab=VDDA}
N 6870 -2020 6870 -1850 {lab=VDDA}
N 5790 -2020 5790 -1850 {lab=VDDA}
N 5750 -1800 5790 -1800 {lab=VDDA}
N 5790 -1850 5790 -1800 {lab=VDDA}
N 6910 -1850 6950 -1850 {lab=VDDA}
N 6870 -1800 6910 -1800 {lab=VDDA}
N 6870 -1850 6870 -1800 {lab=VDDA}
N 6910 -1740 6950 -1740 {lab=VDDA}
N 5540 -440 5540 -360 {
lab=GNDA}
N 5750 -440 5750 -360 {
lab=GNDA}
N 6910 -570 6910 -360 {
lab=GNDA}
N 5500 -330 5540 -330 {
lab=GNDA}
N 5750 -330 5790 -330 {
lab=GNDA}
N 5540 -300 5540 -220 {lab=GNDA}
N 5750 -300 5750 -220 {lab=GNDA}
N 5710 -330 5710 -220 {lab=GNDA}
N 5580 -330 5580 -220 {lab=GNDA}
N 5540 -390 5580 -390 {lab=GNDA}
N 5580 -390 5580 -330 {lab=GNDA}
N 5710 -390 5710 -330 {lab=GNDA}
N 5710 -390 5750 -390 {lab=GNDA}
N 6910 -300 6910 -220 {lab=GNDA}
N 6870 -330 6870 -220 {lab=GNDA}
N 6870 -400 6870 -330 {lab=GNDA}
N 6870 -400 6910 -400 {lab=GNDA}
N 6910 -330 6950 -330 {lab=GNDA}
N 5710 -2020 6950 -2020 {lab=VDDA}
N 7270 -1080 7270 -1030 {
lab=R1_C1}
N 7220 -1110 7250 -1110 {
lab=GNDA}
N 7220 -1110 7220 -940 {
lab=GNDA}
N 7220 -940 7270 -940 {
lab=GNDA}
N 7270 -980 7270 -890 {lab=GNDA}
N 6990 -1190 7540 -1190 {lab=V_CONT}
N 7100 -1190 7100 -1140 {lab=V_CONT}
N 7270 -1190 7270 -1140 {lab=V_CONT}
N 7100 -1080 7100 -990 {lab=GNDA}
N 7740 -1190 8130 -1190 {lab=V_OSC}
N 8310 -1190 8370 -1190 {lab=F_VCO}
N 4130 -2070 4130 -1870 {lab=GNDA}
N 4130 -2920 4130 -2760 {
lab=VDDA}
N 4130 -2730 4170 -2730 {lab=VDDA}
N 4170 -2800 4170 -2730 {lab=VDDA}
N 4130 -2800 4170 -2800 {lab=VDDA}
N 4130 -2610 4230 -2610 {lab=V1}
N 4130 -2700 4130 -2130 {lab=V1}
N 4880 -2590 4920 -2590 {lab=VDDA}
N 4920 -2660 4920 -2590 {lab=VDDA}
N 4880 -2660 4920 -2660 {lab=VDDA}
N 4690 -2590 4840 -2590 {lab=V2}
N 4510 -2570 4560 -2570 {lab=V_CUR_REF_REG}
N 4510 -2570 4510 -2310 {lab=V_CUR_REF_REG}
N 4510 -2310 4880 -2310 {lab=V_CUR_REF_REG}
N 4880 -2560 4880 -2130 {lab=V_CUR_REF_REG}
N 4230 -2610 4560 -2610 {lab=V1}
N 4130 -2920 4880 -2920 {lab=VDDA}
N 4880 -2920 4880 -2620 {lab=VDDA}
N 4130 -1870 4880 -1870 {lab=GNDA}
N 4880 -2070 4880 -1870 {lab=GNDA}
N 4780 -2590 4780 -2490 {lab=V2}
N 4780 -2490 5270 -2490 {lab=V2}
N 3860 -2800 3860 -2730 {lab=V_TOP}
N 3860 -2920 3860 -2860 {lab=VDDA}
N 3720 -2920 4130 -2920 {lab=VDDA}
N 2930 -1870 3310 -1870 {
lab=GNDA}
N 2890 -1950 2890 -1870 {
lab=GNDA}
N 3270 -1950 3270 -1870 {
lab=GNDA}
N 2890 -1870 2930 -1870 {
lab=GNDA}
N 2970 -2810 3110 -2810 {
lab=V_TOP}
N 3110 -2810 3270 -2810 {
lab=V_TOP}
N 2930 -2920 2930 -2840 {
lab=VDDA}
N 2930 -2920 3310 -2920 {
lab=VDDA}
N 3310 -2920 3310 -2840 {
lab=VDDA}
N 3310 -2070 3310 -1980 {lab=Vbe2}
N 3570 -2070 3570 -1870 {lab=GNDA}
N 2690 -2070 2690 -1870 {lab=GNDA}
N 3310 -2810 3350 -2810 {lab=VDDA}
N 3350 -2880 3350 -2810 {lab=VDDA}
N 3310 -2880 3350 -2880 {lab=VDDA}
N 2890 -2810 2930 -2810 {lab=VDDA}
N 2890 -2880 2890 -2810 {lab=VDDA}
N 2890 -2880 2930 -2880 {lab=VDDA}
N 2690 -1870 2890 -1870 {lab=GNDA}
N 3310 -1920 3310 -1870 {lab=GNDA}
N 2930 -1920 2930 -1870 {lab=GNDA}
N 2170 -2810 2170 -2730 {lab=V_TOP}
N 1920 -2670 1920 -2540 {lab=START_UP}
N 1920 -2920 1920 -2840 {
lab=VDDA}
N 1880 -2810 1920 -2810 {lab=VDDA}
N 1880 -2880 1880 -2810 {lab=VDDA}
N 1880 -2880 1920 -2880 {lab=VDDA}
N 1920 -2780 1920 -2670 {lab=START_UP}
N 1920 -2920 2930 -2920 {lab=VDDA}
N 2170 -2810 2730 -2810 {lab=V_TOP}
N 2730 -2810 2730 -2760 {lab=V_TOP}
N 2730 -2760 3050 -2760 {lab=V_TOP}
N 1920 -2700 2130 -2700 {lab=START_UP}
N 1920 -1870 2690 -1870 {lab=GNDA}
N 3050 -2810 3050 -2760 {lab=V_TOP}
N 2170 -2500 2930 -2500 {lab=bgr_Vin-}
N 1880 -2510 1880 -2440 {lab=GNDA}
N 1880 -2510 1920 -2510 {lab=GNDA}
N 1920 -1950 1920 -1870 {lab=GNDA}
N 2170 -2700 2210 -2700 {lab=VDDA}
N 1920 -2130 1920 -1950 {lab=GNDA}
N 1960 -2810 2170 -2810 {lab=V_TOP}
N 1920 -2570 1980 -2570 {lab=START_UP}
N 1980 -2570 1980 -2510 {lab=START_UP}
N 1960 -2510 1980 -2510 {lab=START_UP}
N 2170 -2670 2170 -2500 {lab=bgr_Vin-}
N 2690 -2280 2690 -2130 {lab=bgr_Vin-}
N 3570 -2280 3570 -2130 {lab=bgr_Vin+}
N 3120 -1870 3120 -1800 {lab=GNDA}
N 2630 -2100 2670 -2100 {lab=GNDA}
N 3250 -2100 3290 -2100 {lab=GNDA}
N 3590 -2100 3630 -2100 {lab=GNDA}
N 3030 -2470 3050 -2470 {lab=GNDA}
N 3170 -2470 3190 -2470 {lab=VDDA}
N 2210 -2920 2210 -2700 {lab=VDDA}
N 3130 -2410 3130 -2280 {lab=bgr_Vin+}
N 3090 -2410 3090 -2280 {lab=bgr_Vin-}
N 3130 -2280 3570 -2280 {lab=bgr_Vin+}
N 2690 -2280 3090 -2280 {lab=bgr_Vin-}
N 3110 -2810 3110 -2540 {lab=V_TOP}
N 3310 -2280 3310 -2130 {lab=bgr_Vin+}
N 3310 -2780 3310 -2280 {lab=bgr_Vin+}
N 2930 -2280 2930 -1980 {lab=bgr_Vin-}
N 2930 -2780 2930 -2280 {lab=bgr_Vin-}
N 1880 -2090 1920 -2090 {lab=GNDA}
N 1880 -2160 1880 -2090 {lab=GNDA}
N 1880 -2160 1920 -2160 {lab=GNDA}
N 1920 -2220 1980 -2220 {lab=START_UP_NFET1}
N 1980 -2220 1980 -2160 {lab=START_UP_NFET1}
N 1960 -2160 1980 -2160 {lab=START_UP_NFET1}
N 1920 -2480 1920 -2190 {lab=START_UP_NFET1}
N 3310 -1870 3570 -1870 {lab=GNDA}
N 3570 -1870 4130 -1870 {lab=GNDA}
N 3310 -2920 3720 -2920 {lab=VDDA}
N 3210 -2730 4090 -2730 {lab=V_TOP}
N 3210 -2810 3210 -2730 {lab=V_TOP}
N 4150 -2100 4190 -2100 {lab=GNDA}
N 4820 -2100 4860 -2100 {lab=GNDA}
N 3120 -2990 3120 -2920 {lab=VDDA}
N 5040 -2590 5080 -2590 {lab=VDDA}
N 5040 -2660 5040 -2590 {lab=VDDA}
N 5040 -2660 5080 -2660 {lab=VDDA}
N 5080 -2920 5080 -2620 {lab=VDDA}
N 5080 -2660 5160 -2660 {lab=VDDA}
N 5160 -2660 5160 -2590 {lab=VDDA}
N 5120 -2590 5160 -2590 {lab=VDDA}
N 5080 -2560 5080 -2530 {lab=V_CUR_REF_REG}
N 4880 -2530 5080 -2530 {lab=V_CUR_REF_REG}
N 1880 -2440 1880 -2160 {lab=GNDA}
N 4360 -2920 4360 -2760 {
lab=VDDA}
N 4360 -2730 4400 -2730 {lab=VDDA}
N 4400 -2800 4400 -2730 {lab=VDDA}
N 4360 -2800 4400 -2800 {lab=VDDA}
N 4270 -2730 4320 -2730 {lab=VDDA}
N 4270 -2800 4270 -2730 {lab=VDDA}
N 4270 -2800 4360 -2800 {lab=VDDA}
N 4130 -2660 4360 -2660 {lab=V1}
N 4360 -2700 4360 -2660 {lab=V1}
N 2380 -2670 2380 -2600 {lab=V_TOP}
N 2210 -2700 2380 -2700 {lab=VDDA}
N 2380 -2920 2380 -2730 {lab=VDDA}
N 2420 -2700 2460 -2700 {lab=VDDA}
N 2460 -2780 2460 -2700 {lab=VDDA}
N 2380 -2780 2460 -2780 {lab=VDDA}
N 2170 -2760 2270 -2760 {lab=V_TOP}
N 2270 -2760 2270 -2600 {lab=V_TOP}
N 2270 -2600 2380 -2600 {lab=V_TOP}
N 4880 -2920 5080 -2920 {lab=VDDA}
N 4620 -2700 4620 -2650 {lab=GNDA}
N 4620 -2530 4620 -2480 {lab=VDDA}
N 5310 -2590 5350 -2590 {lab=VDDA}
N 5350 -2660 5350 -2590 {lab=VDDA}
N 5310 -2660 5350 -2660 {lab=VDDA}
N 5310 -2920 5310 -2620 {lab=VDDA}
N 5470 -2590 5510 -2590 {lab=VDDA}
N 5470 -2660 5470 -2590 {lab=VDDA}
N 5470 -2660 5510 -2660 {lab=VDDA}
N 5510 -2920 5510 -2620 {lab=VDDA}
N 5510 -2660 5590 -2660 {lab=VDDA}
N 5590 -2660 5590 -2590 {lab=VDDA}
N 5550 -2590 5590 -2590 {lab=VDDA}
N 5510 -2560 5510 -2530 {lab=I_IN}
N 5310 -2530 5510 -2530 {lab=I_IN}
N 5310 -2920 5510 -2920 {lab=VDDA}
N 5270 -2590 5270 -2490 {lab=V2}
N 5310 -2560 5310 -2300 {lab=I_IN}
N 5080 -2920 5310 -2920 {lab=VDDA}
C {devices/lab_wire.sym} 5030 -1410 0 1 {name=p15 sig_type=std_logic lab=UP_PFD_b}
C {devices/lab_wire.sym} 4730 -1410 0 0 {name=p2 sig_type=std_logic lab=UP_PFD}
C {devices/lab_wire.sym} 4730 -940 2 1 {name=p7 sig_type=std_logic lab=DOWN_PFD}
C {sky130_fd_pr/pfet_01v8.sym} 5250 -840 3 0 {name=M12
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5250 -1050 1 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4870 -990 0 0 {name=M10
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4870 -890 2 1 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4870 -1460 0 0 {name=M14
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 4870 -1360 2 1 {name=M15
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5230 -1460 0 0 {name=M16
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5230 -1360 2 1 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} 7810 -770 0 0 {name=p3 lab=VDDA}
C {devices/opin.sym} 7860 -770 0 0 {name=p11 lab=V_OSC}
C {devices/lab_pin.sym} 4890 -820 0 1 {name=p27 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4890 -1060 0 1 {name=p28 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 5250 -770 0 1 {name=p29 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 5250 -1110 0 1 {name=p30 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 4890 -1290 0 1 {name=p31 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4890 -1530 0 1 {name=p32 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 5250 -1290 0 1 {name=p33 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 5250 -1530 0 1 {name=p34 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 7810 -730 0 0 {name=p35 lab=GNDA}
C {devices/ipin.sym} 7810 -690 0 0 {name=p36 lab=F_REF}
C {sky130_fd_pr/nfet_01v8.sym} 5560 -470 0 1 {name=M22
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5730 -470 0 0 {name=M23
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5770 -1740 2 0 {name=M24
L=0.6
W=8
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 5750 -1150 0 0 {name=p9 sig_type=std_logic lab=x}
C {sky130_fd_pr/pfet_01v8.sym} 6460 -1650 3 0 {name=M25
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6660 -1930 0 0 {name=M26
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6890 -1740 0 0 {name=M27
L=0.6
W=8
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 6120 -1410 2 1 {name=p19 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} 6460 -1450 0 1 {name=p39 sig_type=std_logic lab=UP_b}
C {sky130_fd_pr/nfet_01v8.sym} 6460 -690 1 0 {name=M28
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6660 -440 0 0 {name=M29
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 6120 -940 0 0 {name=p40 sig_type=std_logic lab=DOWN_b}
C {sky130_fd_pr/nfet_01v8.sym} 6890 -600 0 0 {name=M30
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 6700 -1740 2 0 {name=p41 sig_type=std_logic lab=UP_input}
C {devices/lab_wire.sym} 6830 -600 0 0 {name=p42 sig_type=std_logic lab=DOWN_input}
C {devices/lab_wire.sym} 6040 -1740 0 0 {name=p43 sig_type=std_logic lab=opamp_out}
C {sky130_fd_pr/pfet_01v8.sym} 6290 -990 0 0 {name=M31
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -890 2 1 {name=M32
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6290 -1460 0 0 {name=M33
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6290 -1360 2 1 {name=M34
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 5540 -1580 0 1 {name=p44 sig_type=std_logic lab=I_IN}
C {devices/lab_wire.sym} 6460 -940 0 1 {name=p45 sig_type=std_logic lab=DOWN}
C {sky130_fd_pr/nfet_01v8.sym} 6460 -1830 1 0 {name=M35
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6460 -510 3 0 {name=M36
L=0.15
W=2
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6600 -1570 0 0 {name=C1 model=cap_mim_m3_1 W=7 L=6.3 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 6600 -770 2 0 {name=C2 model=cap_mim_m3_1 W=3.8 L=2.6 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 6260 -2080 0 1 {name=p26 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6260 -160 0 1 {name=p18 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 6310 -1530 0 1 {name=p5 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6310 -1290 0 1 {name=p6 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 6310 -1060 0 1 {name=p8 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6310 -820 0 1 {name=p10 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 6520 -560 0 1 {name=p13 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6520 -640 0 1 {name=p14 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 6520 -1700 0 1 {name=p16 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6520 -1780 0 1 {name=p17 sig_type=std_logic lab=GNDA}
C {devices/lab_wire.sym} 5040 -940 2 0 {name=p1 sig_type=std_logic lab=DOWN_b_b}
C {devices/lab_pin.sym} 5870 -1250 0 0 {name=p4 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 6010 -1250 0 1 {name=p20 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4130 -1270 0 0 {name=p21 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 4130 -1150 0 0 {name=p22 sig_type=std_logic lab=GNDA}
C {devices/lab_wire.sym} 4280 -1230 0 1 {name=p23 sig_type=std_logic lab=UP_PFD}
C {devices/lab_wire.sym} 4280 -1190 2 0 {name=p24 sig_type=std_logic lab=DOWN_PFD}
C {devices/lab_wire.sym} 3980 -1230 0 0 {name=p25 sig_type=std_logic lab=F_REF}
C {devices/lab_wire.sym} 3980 -1190 2 1 {name=p46 sig_type=std_logic lab=F_VCO}
C {/foss/designs/my_design/projects/pll/pfd/xschem_ngspice/phase_frequency_detector_5.sym} 4130 -1210 0 0 {name=x2}
C {sky130_fd_pr/pfet_01v8.sym} 5770 -1850 0 1 {name=M19
L=0.6
W=4
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 6890 -1850 0 0 {name=M20
L=0.6
W=4
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5730 -330 0 0 {name=M21
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 5560 -330 0 1 {name=M37
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 6890 -330 0 0 {name=M38
L=0.6
W=4
nf=2 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/foss/designs/my_design/projects/pll/charge_pump/xschem_ngspice/rail_to_rail_opamp6_3.sym} 5940 -1250 3 0 {name=x1}
C {devices/lab_pin.sym} 7270 -890 0 1 {name=p49 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7100 -1110 2 0 {name=C3 model=cap_mim_m3_1 W=13.8 L=60 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 7270 -1010 2 0 {name=C4 model=cap_mim_m3_1 W=69.8 L=60 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 7270 -1110 0 0 {name=R1
L=7.52
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_pin.sym} 7100 -990 0 1 {name=p51 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 7270 -1060 0 1 {name=p52 sig_type=std_logic lab=R1_C1}
C {lab_pin.sym} 7640 -1290 0 0 {name=p47 lab=VDDA}
C {lab_pin.sym} 7640 -1090 0 0 {name=p50 lab=GNDA}
C {lab_pin.sym} 8220 -1240 0 0 {name=p54 lab=VDDA}
C {lab_pin.sym} 8220 -1140 0 0 {name=p55 lab=GNDA}
C {lab_wire.sym} 7970 -1190 2 0 {name=p56 sig_type=std_logic lab=V_OSC}
C {/foss/designs/my_design/projects/pll/vco/xschem_ngspice/current_starved_VCO12.sym} 7640 -1190 0 0 {name=x3}
C {/foss/designs/my_design/projects/pll/divider/xschem_ngspice/divide_by_120/divide_by_120_xschem.sym} 8220 -1190 0 0 {name=x4}
C {devices/lab_wire.sym} 8370 -1190 2 0 {name=p48 sig_type=std_logic lab=F_VCO}
C {lab_wire.sym} 7480 -1190 0 0 {name=p12 sig_type=std_logic lab=V_CONT}
C {sky130_fd_pr/pfet_01v8.sym} 4110 -2730 0 0 {name=M45
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 4130 -2100 0 1 {name=R4
L=10
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 4880 -2100 0 0 {name=R5
L=1
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 4860 -2590 0 0 {name=M50
W=10
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4880 -2310 0 1 {name=p37 sig_type=std_logic lab=V_CUR_REF_REG}
C {lab_wire.sym} 3960 -2730 2 0 {name=p53 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3860 -2830 2 0 {name=C5 model=cap_mim_m3_1 W=2 L=2 MF=20 spiceprefix=X}
C {devices/lab_pin.sym} 3310 -2020 2 0 {name=p67 sig_type=std_logic lab=Vbe2}
C {sky130_fd_pr/pnp_05v5.sym} 2910 -1950 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 3290 -1950 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2950 -2810 0 1 {name=M51
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3290 -2810 0 0 {name=M53
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 3210 -2280 2 0 {name=p70 sig_type=std_logic lab=bgr_Vin+}
C {lab_wire.sym} 3020 -2280 2 1 {name=p71 sig_type=std_logic lab=bgr_Vin-}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 3310 -2100 0 0 {name=R3
L=2.3
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 3570 -2100 0 1 {name=R6
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2690 -2100 0 0 {name=R7
L=18
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} 1940 -2510 0 1 {name=M54
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1940 -2810 0 1 {name=M55
W=12
L=0.5
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1920 -2700 2 1 {name=p72 sig_type=std_logic lab=START_UP}
C {lab_wire.sym} 2170 -2810 0 0 {name=p73 sig_type=std_logic lab=V_TOP}
C {sky130_fd_pr/pfet_01v8.sym} 2150 -2700 0 0 {name=M56
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1940 -2160 0 1 {name=M57
W=1
L=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1920 -2400 2 0 {name=p90 sig_type=std_logic lab=START_UP_NFET1}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 3110 -2470 1 1 {name=x5}
C {/foss/designs/my_design/projects/bandgapref/xschem_ngspice/new_files/opamp_bandgap_2.sym} 4620 -2590 2 1 {name=x6}
C {lab_wire.sym} 5270 -2490 2 0 {name=p95 sig_type=std_logic lab=V2}
C {sky130_fd_pr/pfet_01v8.sym} 5100 -2590 0 1 {name=M80
W=10
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 4340 -2730 0 0 {name=M83
W=6
L=0.5
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2400 -2700 0 1 {name=M92
W=2
L=0.15
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_wire.sym} 4130 -2490 0 0 {name=p57 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 3190 -2470 2 0 {name=p60 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 3030 -2470 2 1 {name=p61 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 2630 -2100 2 1 {name=p62 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 3250 -2100 2 1 {name=p63 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 3630 -2100 2 0 {name=p64 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4620 -2700 2 0 {name=p65 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4620 -2480 2 0 {name=p66 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 4190 -2100 2 0 {name=p68 sig_type=std_logic lab=GNDA}
C {devices/lab_pin.sym} 4820 -2100 2 1 {name=p69 sig_type=std_logic lab=GNDA}
C {sky130_fd_pr/pfet_01v8.sym} 5290 -2590 0 0 {name=M1
W=10
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 5530 -2590 0 1 {name=M2
W=10
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 5310 -2300 2 0 {name=p74 sig_type=std_logic lab=I_IN}
C {devices/lab_pin.sym} 3120 -2990 0 1 {name=p58 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 3120 -1800 0 1 {name=p59 sig_type=std_logic lab=GNDA}
