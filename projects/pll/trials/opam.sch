v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 170 -40 0 0 {name=l1 author="Jae Young Yoon"}
