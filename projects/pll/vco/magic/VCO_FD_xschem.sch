v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 300 -200 560 -200 {lab=V_OSC}
C {lab_pin.sym} 200 -300 0 0 {name=p1 lab=VDDA}
C {lab_pin.sym} 100 -200 0 0 {name=p2 lab=V_CONT}
C {lab_pin.sym} 200 -100 0 0 {name=p3 lab=GNDA}
C {lab_pin.sym} 740 -200 0 1 {name=p4 lab=V_OUT_120}
C {lab_pin.sym} 650 -250 0 0 {name=p5 lab=VDDA}
C {lab_pin.sym} 650 -150 0 0 {name=p6 lab=GNDA}
C {lab_wire.sym} 400 -200 2 0 {name=p7 sig_type=std_logic lab=V_OSC}
C {ipin.sym} 390 -100 0 0 {name=p8 lab=VDDA}
C {opin.sym} 440 -100 0 0 {name=p9 lab=V_OUT_120}
C {ipin.sym} 390 -70 0 0 {name=p10 lab=GNDA}
C {ipin.sym} 390 -40 0 0 {name=p11 lab=V_CONT}
C {/foss/designs/my_design/projects/pll/vco/xschem_ngspice/current_starved_VCO12.sym} 200 -200 0 0 {name=x1}
C {/foss/designs/my_design/projects/pll/divider/xschem_ngspice/divide_by_120/divide_by_120_xschem.sym} 650 -200 0 0 {name=x2}
